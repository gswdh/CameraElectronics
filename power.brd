# Repository gswdh/CameraElectronics (continued)

## EAGLE design power.brd (continued)

Parts:
U3: STM32G030C8; QFP48

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Board: 4 copper layers, 80.0 x 220.0 mm, 78 parts (56 on the bottom side), 42 nets.

## EAGLE design main.brd

Notes on the sheet:
2024.02.14 - GSWDH LTD. CAMERA MAIN PCB REVISION 1.2.0 DESIGN BY GEORGE WALLER, GSWDH LTD. GEORGEWALLER@GSWDH.CO.UK CONFIDENTIAL. FOR THE INTENDED READER ONLY.
UNCONTROLLED WHEN PRINTED

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Parts:
R14, R15, R25, R26, R69, R70, R110, R112, R117, R118, R127, R128, R134, R138, R143, R144, R149, R150, R155, R156: 150R; 0402
R19, R20, R64, R66, R71, R73, R113, R114, R123, R124, R130, R131, R139, R140, R145, R146, R151, R152, R157, R158: 120R; 0402
R21, R27, R67, R68, R96, R109, R115, R116, R125, R126, R132, R133, R141, R142, R147, R148, R153, R154, R159, R160: 60.4R; 0402

Connections:
EVF_MIPI_A_CLK_N: R112.2, R114.1, R116.2; also elsewhere on the board
EVF_MIPI_A_CLK_P: R110.2, R113.1, R115.2; also elsewhere on the board
EVF_MIPI_A_D0_N: R15.2, R20.1, R27.2; also elsewhere on the board
EVF_MIPI_A_D0_P: R14.2, R19.1, R21.2; also elsewhere on the board
EVF_MIPI_A_D1_N: R118.2, R124.1, R126.2; also elsewhere on the board
EVF_MIPI_A_D1_P: R117.2, R123.1, R125.2; also elsewhere on the board
EVF_MIPI_A_D2_N: R144.2, R146.1, R148.2; also elsewhere on the board
EVF_MIPI_A_D2_P: R143.2, R145.1, R147.2; also elsewhere on the board
EVF_MIPI_A_D3_N: R138.2, R140.1, R142.2; also elsewhere on the board
EVF_MIPI_A_D3_P: R134.2, R139.1, R141.2; also elsewhere on the board
EVF_MIPI_B_CLK_N: R156.2, R158.1, R160.2; also elsewhere on the board
EVF_MIPI_B_CLK_P: R155.2, R157.1, R159.2; also elsewhere on the board
EVF_MIPI_B_D0_N: R150.2, R152.1, R154.2; also elsewhere on the board
EVF_MIPI_B_D0_P: R149.2, R151.1, R153.2; also elsewhere on the board
EVF_MIPI_B_D1_N: R70.2, R73.1, R109.2; also elsewhere on the board
EVF_MIPI_B_D1_P: R69.2, R71.1, R96.2; also elsewhere on the board
EVF_MIPI_B_D2_N: R26.2, R66.1, R68.2; also elsewhere on the board
EVF_MIPI_B_D2_P: R25.2, R64.1, R67.2; also elsewhere on the board
EVF_MIPI_B_D3_N: R128.2, R131.1, R133.2; also elsewhere on the board
EVF_MIPI_B_D3_P: R127.2, R130.1, R132.2; also elsewhere on the board
GND: R19.2, R20.2, R64.2, R66.2, R71.2, R73.2, R113.2, R114.2, R123.2, R124.2, R130.2, R131.2, R139.2, R140.2, R145.2, R146.2, R151.2, R152.2, R157.2, R158.2; also elsewhere on the board
MIPI_DSI_A_HS_CK_N: R112.1
MIPI_DSI_A_HS_CK_P: R110.1
MIPI_DSI_A_HS_L0_N: R15.1
MIPI_DSI_A_HS_L0_P: R14.1
MIPI_DSI_A_HS_L1_N: R118.1
MIPI_DSI_A_HS_L1_P: R117.1
MIPI_DSI_A_HS_L2_N: R144.1
MIPI_DSI_A_HS_L2_P: R143.1
MIPI_DSI_A_HS_L3_N: R138.1
MIPI_DSI_A_HS_L3_P: R134.1
MIPI_DSI_A_LP_CK_N: R116.1
MIPI_DSI_A_LP_CK_P: R115.1
MIPI_DSI_A_LP_L0_N: R27.1
MIPI_DSI_A_LP_L0_P: R21.1
MIPI_DSI_A_LP_L1_N: R126.1
MIPI_DSI_A_LP_L1_P: R125.1
MIPI_DSI_A_LP_L2_N: R148.1
MIPI_DSI_A_LP_L2_P: R147.1
MIPI_DSI_A_LP_L3_N: R142.1
MIPI_DSI_A_LP_L3_P: R141.1
MIPI_DSI_B_HP_L3_N: R128.1
MIPI_DSI_B_HP_L3_P: R127.1
MIPI_DSI_B_HS_CK_N: R156.1
MIPI_DSI_B_HS_CK_P: R155.1
MIPI_DSI_B_HS_L0_N: R150.1
MIPI_DSI_B_HS_L0_P: R149.1
MIPI_DSI_B_HS_L1_N: R70.1
MIPI_DSI_B_HS_L1_P: R69.1
MIPI_DSI_B_HS_L2_N: R26.1
MIPI_DSI_B_HS_L2_P: R25.1
MIPI_DSI_B_LP_CK_N: R160.1
MIPI_DSI_B_LP_CK_P: R159.1
MIPI_DSI_B_LP_L0_N: R154.1
MIPI_DSI_B_LP_L0_P: R153.1
MIPI_DSI_B_LP_L1_N: R109.1
MIPI_DSI_B_LP_L1_P: R96.1
MIPI_DSI_B_LP_L2_N: R68.1
MIPI_DSI_B_LP_L2_P: R67.1
MIPI_DSI_B_LP_L3_N: R133.1
MIPI_DSI_B_LP_L3_P: R132.1

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Parts:
CN1: 10/100 RJ45; ARJC02
CN3: 632723300011; CONN_632723X0001_WRE

Connections:
GND: CN3.1 (SHELL), CN3.2 (SHELL), CN3.3 (SHELL), CN3.4 (SHELL), CN3.A1 (GND), CN3.A12 (GND), CN3.B1 (GND), CN3.B12 (GND); also elsewhere on the board

Notes on the sheet:
UNCONTROLLED WHEN PRINTED
