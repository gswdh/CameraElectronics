# Repository gswdh/CameraElectronics

## EAGLE design power.brd

Notes on the sheet:
2024.09.15- GSWDH LTD. CAMERA POWER PCB REVISION 1.2.1 DESIGN BY GEORGE WALLER, GSWDH LTD. GEORGEWALLER@GSWDH.CO.UK CONFIDENTIAL. FOR THE INTENDED READER ONLY.
UNCONTROLLED WHEN PRINTED

Parts:
C1, C2, C4, C5, C21: 100nF 16V; 0603
C6, C7, C8, C9: 470nF 25V; 0603
C10: 10nF 50V; 0603
CN3, CN4, CN5, CN6, CN9, CN10, CN11, CN12, CN15, CN16, CN17, CN18, CN21, CN22, CN23, CN24: 21700 CLIP; KEYSTONE_247
Q1, Q2: SIRA36DP-T1-GE3; SO8_POWERPAK
R1: 10R; 0603
R2, R3, R4, R5: 47R; 0603
R6, R10, R12: 1.0k; 0603
R7, R9: 100R; 0603
R8: 0R01; 1206
R11: 10k; 0603
U1: MAX17320G20+; TQFN24

Connections:
BMS_I2C_SCL: U1.8 (SCL/OD)
BMS_I2C_SDA: U1.9 (SDA/DQ)
BMS_NALERT: U1.7 (ALRT)
BMS_TH1: R11.2, U1.10 (TH1)
GND: R8.1, U1.14 (CSN); also elsewhere on the board
unnamed: C1.2, R2.2, U1.24 (BATTS)
unnamed: C1.1, C2.2, R3.2, U1.23 (CELL3)
unnamed: C4.2, C21.1, R4.2, U1.21 (CELL1)
unnamed: CN22.1, CN22.2, CN22.3, CN24.1, CN24.2, CN24.3, Q1.1 (S), Q1.2 (S), Q1.3 (S), R1.1, R2.1
unnamed: CN4.1, CN4.2, CN4.3, CN6.1, CN6.2, CN6.3, CN9.1, CN9.2, CN9.3, CN11.1, CN11.2, CN11.3, R4.1
unnamed: CN10.1, CN10.2, CN10.3, CN12.1, CN12.2, CN12.3, CN15.1, CN15.2, CN15.3, CN17.1, CN17.2, CN17.3, R5.1
unnamed: CN16.1, CN16.2, CN16.3, CN18.1, CN18.2, CN18.3, CN21.1, CN21.2, CN21.3, CN23.1, CN23.2, CN23.3, R3.1
unnamed: C5.2, C6.1, R1.2, U1.1 (IN)
unnamed: C6.2, U1.2 (CP)
unnamed: Q2.4 (G), R9.2
unnamed: R6.2, U1.11 (PFAIL)
unnamed: C10.2, R12.1, U1.6 (PCKP)
unnamed: R10.1, U1.5 (ZVC)
unnamed: C7.1, U1.12 (AOLDO)
unnamed: C8.1, U1.17 (REG2)
unnamed: C9.1, U1.13 (REG3)
unnamed: R9.1, U1.4 (DIS)
unnamed: Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), Q1.PAD (D), Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), Q2.PAD (D)
unnamed: Q1.4 (G), R7.2
unnamed: R7.1, U1.3 (CHG)
unnamed: C2.1, C21.2, R5.2, U1.22 (CELL2)
PGND: C4.1, C5.1, C7.2, C8.2, C9.2, C10.1, CN3.1, CN3.2, CN3.3, CN5.1, CN5.2, CN5.3, R6.1, R8.2, R11.1, U1.15 (CSP), U1.16 (TH2), U1.18 (TH3), U1.19 (TH4), U1.20 (GND), U1.PAD (GND)
PWR_BAT_VPACK: Q2.1 (S), Q2.2 (S), Q2.3 (S), R10.2, R12.2; also elsewhere on the board

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Parts:
C3, C11, C15, C16: 47pF 25V; 0402
C12, C17, C23, C27: 10uF 50V; 1210
C13, C14, C18, C19, C22, C24, C25, C26: 22uF 50V; 2220
C20: 0.1uF 50V; 0603
MECH2, MECH3, MECH4, MECH6, MECH8, MECH10: 6mm x 3mm; MOUNTHOLE_6X3
R13: 0R082; 2512
R14: 150k; 0402
R15: 12k; 0402
R16, R18, R25: 10k; 0402
R17, R23: 45.3k; 0402
R20: 75k; 0402
R21: 5.1k; 0402
U2, U6: LTM8055; BGA121-1.27MM
U5: NCS20071; SOT23-5

Connections:
CHRG_ENABLE: R25.1, U2.L4 (RUN)
CHRG_IOUT_CTL: R18.1, U5.3 (+)
GND: C3.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, R15.2, R16.2, R17.1, R18.2, R21.2, R23.1, R25.2, U2.A7 (GND), U2.A8 (GND), U2.A9 (GND), U2.A10 (GND), U2.A11 (GND), U2.B7 (GND), U2.B8 (GND), U2.B9 (GND), U2.B10 (GND), U2.B11 (GND), U2.C7 (GND), U2.C8 (GND), U2.C9 (GND), U2.C10 (GND), U2.C11 (GND), U2.D2 (GND), U2.D3 (GND), U2.D4 (GND), U2.D5 (GND), U2.D6 (GND), U2.D7 (GND), U2.D8 (GND), U2.D9 (GND), U2.D10 (GND), U2.D11 (GND), U2.E1 (GND), U2.E2 (GND), U2.E3 (GND), U2.E4 (GND), U2.E5 (GND), U2.E6 (GND), U2.E7 (GND), U2.E8 (GND), U2.E9 (GND), U2.E10 (GND), U2.E11 (GND), U2.F2 (GND), U2.F3 (GND), U2.F4 (GND), U2.F5 (GND), U2.F6 (GND), U2.F7 (GND), U2.F8 (GND), U2.F9 (GND), U2.G3 (GND), U2.G4 (GND), U2.G5 (GND), U2.G6 (GND), U2.G7 (GND), U2.G8 (GND), U2.G9 (GND), U2.H2 (SYNC), U2.H3 (GND), U2.H4 (GND), U2.H5 (GND), U2.H6 (GND)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; also elsewhere on the board
unnamed: C13.2, C14.2, C25.2, C26.2, R13.1, R14.2, U2.A1 (V_OUT), U2.A2 (V_OUT), U2.A3 (V_OUT), U2.A4 (V_OUT), U2.A5 (V_OUT), U2.A6 (V_OUT), U2.B1 (V_OUT), U2.B2 (V_OUT), U2.B3 (V_OUT), U2.B4 (V_OUT), U2.B5 (V_OUT), U2.B6 (V_OUT), U2.C1 (V_OUT), U2.C2 (V_OUT), U2.C3 (V_OUT), U2.C4 (V_OUT), U2.C5 (V_OUT), U2.C6 (V_OUT)
unnamed: R14.1, R15.1, U2.J1 (FB)
unnamed: R17.2, U2.H1 (RT)
unnamed: C3.2, U2.J2 (COMP)
unnamed: U2.K2 (CTL), U5.1 (OUT), U5.4 (-)
unnamed: U2.F1 (LL), U2.G2 (MODE)
unnamed: C11.2, U2.K1 (SS)
unnamed: R20.1, R21.1, U6.J1 (FB)
unnamed: R23.2, U6.H1 (RT)
unnamed: C15.2, U6.J2 (COMP)
unnamed: U6.F1 (LL), U6.G2 (MODE)
unnamed: C16.2, U6.K1 (SS)
PWR_BAT_VPACK: C17.2, C27.2, R13.2, U2.D1 (I_OUT), U6.F10 (SV_IN), U6.F11 (SV_IN), U6.G10 (V_IN), U6.G11 (V_IN), U6.H10 (V_IN), U6.H11 (V_IN), U6.J10 (V_IN), U6.J11 (V_IN), U6.K10 (V_IN), U6.K11 (V_IN), U6.L9 (I_IN), U6.L10 (V_IN), U6.L11 (V_IN); also elsewhere on the board
PWR_SYS_19V: C18.2, C19.2, C22.2, C24.2, R20.2, U6.A1 (V_OUT), U6.A2 (V_OUT), U6.A3 (V_OUT), U6.A4 (V_OUT), U6.A5 (V_OUT), U6.A6 (V_OUT), U6.B1 (V_OUT), U6.B2 (V_OUT), U6.B3 (V_OUT), U6.B4 (V_OUT), U6.B5 (V_OUT), U6.B6 (V_OUT), U6.C1 (V_OUT), U6.C2 (V_OUT), U6.C3 (V_OUT), U6.C4 (V_OUT), U6.C5 (V_OUT), U6.C6 (V_OUT), U6.D1 (I_OUT)
PWR_SYS_19V_EN: R16.1, U6.L4 (RUN)
PWR_SYS_VIN_COND: C12.2, C20.2, C23.2, U2.F10 (SV_IN), U2.F11 (SV_IN), U2.G10 (V_IN), U2.G11 (V_IN), U2.H10 (V_IN), U2.H11 (V_IN), U2.J10 (V_IN), U2.J11 (V_IN), U2.K10 (V_IN), U2.K11 (V_IN), U2.L9 (I_IN), U2.L10 (V_IN), U2.L11 (V_IN), U5.5 (V+)

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Notices in the files:
parts and their libraries:
tag-connect: ©2009 ROFA.cz - modified and updated by Robert Darlington ‹rdarlington@gmail.com›
