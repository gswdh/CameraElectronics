# Repository gswdh/CameraElectronics (continued)

## EAGLE design ethernet.brd

Notes on the sheet:
2023.10.24- GSWDH LTD. CAMERA POWER PCB REVISION 1.2.0 DESIGN BY GEORGE WALLER, GSWDH LTD. GEORGEWALLER@GSWDH.CO.UK CONFIDENTIAL. FOR THE INTENDED READER ONLY.
UNCONTROLLED WHEN PRINTED

Parts:
CN1: HFJ11-1G01ERL; HFJ11-1G
MECH1, MECH2: 6mm x 3mm; MOUNTHOLE_6X3
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12: TEST_POINT_SQUARE; OSPREY_HSS_PAD

Connections:
GND: CN1.10 (GND), CN1.12 (K), CN1.SH1 (GND), CN1.SH2 (GND), TP12.1
LED_AMBER: CN1.14 (K), TP11.1
LED_GREEN: CN1.11 (A), TP10.1
unnamed: CN1.1 (TRD1+), TP1.1
unnamed: CN1.2 (TRD1-), TP2.1
unnamed: CN1.3 (TRD2+), TP3.1
unnamed: CN1.6 (TRD2-), TP4.1
unnamed: CN1.4 (TRD3+), TP5.1
unnamed: CN1.5 (TRD3-), TP6.1
unnamed: CN1.7 (TRD4+), TP7.1
unnamed: CN1.8 (TRD4-), TP8.1
PWR_SYS_3V3: CN1.13 (A), TP9.1

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Board: 8 copper layers, 60.0 x 22.0 mm, 15 parts (0 on the bottom side), 12 nets.

## EAGLE design debug.brd

Notes on the sheet:
2023.07.25 - GSWDH LTD. CAMERA DEBUG PCB REVISION 1.0.0 DESIGN BY GEORGE WALLER, GSWDH LTD. GEORGEWALLER@GSWDH.CO.UK CONFIDENTIAL. FOR THE INTENDED READER ONLY.
UNCONTROLLED WHEN PRINTED

Parts:
C1, C3, C4, C6, C7, C8, C9, C11, C12: 0.1uF 16V; 0603
C2, C5, C10: 2.2uF 25V; 0603
CN1, CN5: 2X10 HEADER; 2X10PIN_HEADER
CN2: JTAG PROG; 2X7HEADER
CN3: 50 PIN 0.5MM; FH52E-50S-0.5SH
CN4, CN6, CN7: MICRO USB B; ZX62-B-5PA(33)
CN8: 2X4_HEADER; 4X2_HEADER
D1: RED LED; 0603_POLAR
FB1, FB2, FB3: 150R 100MHz; 1206
Q1, Q2: MMBT3904; SOT23-3
Q3: 2N7002; SOT23-3
R1, R2: 4.7k; 0603
R4, R5: 10k; 0603
U1, U2, U5: USBLC6-2SC6; SOT23-6
U3, U4, U6: FT231X; SSOP20-4MM

Connections:
BMS_I2C_SCL: CN3.P10, CN8.6
BMS_I2C_SDA: CN3.P11, CN8.7
BMS_NINT: CN3.P12, CN8.8
ESP32_EN: CN3.P15, Q1.2 (C)
ESP32_UART_!DTR: Q2.3 (E), R4.2, U3.1 (!DTR)
ESP32_UART_!RTS: Q1.3 (E), R5.2, U3.2 (!RTS)
ESP32_UART_RX: CN3.P17, U3.20 (TXD)
ESP32_UART_TX: CN3.P16, U3.4 (RXD)
ESP_IO0: CN3.P18, Q2.2 (C)
FPGA_DEBUG_CLK: CN3.P31, CN5.1
FPGA_DEBUG_D0: CN3.P40, CN5.10
FPGA_DEBUG_D1: CN3.P39, CN5.9
FPGA_DEBUG_D2: CN3.P38, CN5.8
FPGA_DEBUG_D3: CN3.P37, CN5.7
FPGA_DEBUG_D4: CN3.P36, CN5.6
FPGA_DEBUG_D5: CN3.P35, CN5.5
FPGA_DEBUG_D6: CN3.P34, CN5.4
FPGA_DEBUG_D7: CN3.P33, CN5.3
FPGA_DEBUG_EN: CN3.P32, CN5.2
FPGA_DONE: CN3.P45, Q3.1 (G), R1.1
FPGA_JTAG_TCK: CN2.12 (TCK), CN3.P47
FPGA_JTAG_TDI: CN2.10 (TDI), CN3.P48
FPGA_JTAG_TDO: CN2.11 (TDO), CN3.P46
FPGA_JTAG_TMS: CN2.13 (TMS), CN3.P49
FPGA_NINIT: CN3.P44
FPGA_NPROG: CN3.P43
FPGA_PS_NSRST: CN2.8 (PS_NSRST), CN3.P24
FPGA_STATUS_D0: CN3.P28
FPGA_STATUS_D1: CN3.P27
FPGA_STATUS_D2: CN3.P26
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, CN1.11, CN1.12, CN1.13, CN1.14, CN1.15, CN1.16, CN1.17, CN1.18, CN1.19, CN2.1 (GND), CN2.2 (GND), CN2.3 (GND), CN2.4 (GND), CN2.5 (GND), CN2.6 (GND), CN2.7 (GND), CN3.P1, CN3.P8, CN3.P13, CN3.P19, CN3.P25, CN3.P29, CN3.P41, CN3.P50, CN3.SH1 (GND), CN3.SH2 (GND), CN4.5 (GND), CN4.SH1 (GND), CN4.SH2 (GND), CN4.SH3 (GND), CN4.SH4 (GND), CN4.SH5 (GND), CN4.SH6 (GND), CN5.11, CN5.12, CN5.13, CN5.14, CN5.15, CN5.16, CN5.17, CN5.18, CN5.19, CN5.20, CN6.5 (GND), CN6.SH1 (GND), CN6.SH2 (GND), CN6.SH3 (GND), CN6.SH4 (GND), CN6.SH5 (GND), CN6.SH6 (GND), CN7.5 (GND), CN7.SH1 (GND), CN7.SH2 (GND), CN7.SH3 (GND), CN7.SH4 (GND), CN7.SH5 (GND), CN7.SH6 (GND), CN8.1, CN8.2, CN8.3, CN8.4, Q3.3 (S), U1.2 (GND), U2.2 (GND), U3.6 (GND), U3.16 (GND), U4.6 (GND), U4.16 (GND)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
unnamed: CN6.1 (5V), FB1.1
unnamed: CN6.3 (D+), U2.1 (D+_IN)
unnamed: CN7.1 (5V), FB3.1
unnamed: CN7.3 (D+), U5.1 (D+_IN)
unnamed: CN6.2 (D-), U2.3 (D-_IN)
unnamed: C5.2, U4.13 (3V3OUT)
unnamed: U2.4 (D-OUT), U4.12 (D-)
unnamed: CN4.1 (5V), FB2.1
unnamed: CN4.3 (D+), U1.1 (D+_IN)
unnamed: CN4.2 (D-), U1.3 (D-_IN)
unnamed: U1.4 (D-OUT), U3.12 (D-)
unnamed: C2.2, U3.13 (3V3OUT)
unnamed: U1.6 (D+_OUT), U3.11 (D+)
unnamed: Q3.2 (D), R2.1
unnamed: U2.6 (D+_OUT), U4.11 (D+)
unnamed: CN7.2 (D-), U5.3 (D-_IN)
unnamed: C10.2, U6.13 (3V3OUT)
unnamed: U5.4 (D-OUT), U6.12 (D-)
unnamed: U5.6 (D+_OUT), U6.11 (D+)
unnamed: D1.K, R2.2
unnamed: Q1.1 (B), R4.1
unnamed: Q2.1 (B), R5.1
PMC_NRESET: CN1.8, CN3.P6
PMC_SWCLK: CN1.5, CN3.P5
PMC_SWDIO: CN1.4, CN3.P4
PMC_UART_RX: CN3.P3, U6.20 (TXD)
PMC_UART_TX: CN3.P2, U6.4 (RXD)
PSS_DEBUG_UART_RX: CN3.P22, U4.20 (TXD)
PSS_DEBUG_UART_TX: CN3.P21, U4.4 (RXD)
PWR_SYS_1V8: C8.2, CN3.P20, U4.3 (VCCIO), U4.14 (!RESET)
PWR_SYS_1V8_SLP: C12.2, CN1.1, CN3.P7, CN3.P9, CN8.5, U6.3 (VCCIO), U6.14 (!RESET)
PWR_SYS_3V3: C6.2, CN2.14 (VREF), CN3.P14, CN3.P30, CN3.P42, D1.A, R1.2, U3.3 (VCCIO), U3.14 (!RESET)
USB_VBUS: C1.2, C3.2, FB2.2, U1.5 (VBUS), U3.15 (VCC)
USB_VBUS1: C4.2, C7.2, FB1.2, U2.5 (VBUS), U4.15 (VCC)
USB_VBUS2: C9.2, C11.2, FB3.2, U5.5 (VBUS), U6.15 (VCC)

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Board: 4 copper layers, 120.0 x 50.0 mm, 37 parts (0 on the bottom side), 61 nets.

## EAGLE design rig.brd

Schematic: rig.sch, sheet 1, TITLE

Notes on the sheet:
YYYY.MM.DD - GSWDH LTD. CAMERA MAIN PCB REVISION 1.x.x DESIGN BY GEORGE WALLER, GSWDH LTD. GEORGEWALLER@GSWDH.CO.UK CONFIDENTIAL. FOR THE INTENDED READER ONLY.
UNCONTROLLED WHEN PRINTED

Schematic: rig.sch, sheet 2, FPGA

Parts:
D11: RGB LED; CLX6F-FKC
MECH5, MECH6, MECH7, MECH8, MECH9, MECH10: 6mm x 3mm; MOUNTHOLE_6X3
Q4, Q6, Q7: 2N7002; SOT23-3
R109, R110, R111: 4.99k; 0603
R112: 82R; 0603
R113: 62R; 0603
R114: 30R; 0603
SW2, SW3, SW4, SW5: SM TACT; CS11043.8F180
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP26, TP27, TP28, TP29, TP30, TP31, TP32, TP33, TP34, TP35, TP36, TP37, TP38, TP39, TP40, TP41, TP42, TP43, TP44, TP45, TP46, TP47, TP48, TP49, TP50, TP51, TP52, TP53, TP54, TP55, TP56, TP57, TP58, TP59, TP60, TP61, TP62, TP63, TP64, TP65, TP66, TP67, TP68, TP69, TP70, TP71, TP72, TP73, TP74, TP75, TP76, TP77, TP78, TP79, TP80, TP81, TP82, TP83, TP84, TP85, TP86, TP87, TP88, TP89, TP90, TP91, TP92, TP93, TP94, TP95, TP96, TP97, TP98, TP99, TP100, TP101, TP102, TP103: 0914-3; 0914

Connections:
ACT_I2C_SCL: TP79.1
ACT_I2C_SDA: TP78.1
ACT_NCHG: TP74.1
ACT_NINT: TP75.1
BMS_I2C_SCL: TP76.1
BMS_I2C_SDA: TP77.1
BMS_NINT: TP70.1
BMS_NPRESENT: TP71.1
BTN_MANAUTO: SW5.1, SW5.2 (1), TP34.1
BTN_ONOFF: SW4.1, SW4.2 (1), TP72.1
BTN_SHUTTER: SW2.1, SW2.2 (1), TP31.1
BTN_ZOOM: SW3.1, SW3.2 (1), TP32.1
CNT_UART_RX: TP28.1
CNT_UART_TX: TP29.1
DDR_VTT: TP38.1
DDR_VTTREF: TP39.1
DEBUG_GPIO_0: TP27.1
DEBUG_GPIO_1: TP58.1
FPGA_CFG: TP3.1
FPGA_DEBUG_CLK: TP12.1
FPGA_DEBUG_D0: TP14.1
FPGA_DEBUG_D1: TP15.1
FPGA_DEBUG_D2: TP17.1
FPGA_DEBUG_D3: TP16.1
FPGA_DEBUG_D4: TP18.1
FPGA_DEBUG_D5: TP19.1
FPGA_DEBUG_D6: TP20.1
FPGA_DEBUG_D7: TP21.1
FPGA_DEBUG_EN: TP13.1
FPGA_DONE: TP4.1
FPGA_JTAG_NRESET: TP5.1
FPGA_NINIT: TP1.1
FPGA_NPROG: TP2.1
FPGA_TCK: TP6.1
FPGA_TDI: TP9.1
FPGA_TDO: TP8.1
FPGA_TMS: TP7.1
FPGA_UART_RX: TP10.1
FPGA_UART_TX: TP11.1
FT_PWR_1V0: TP45.1
GND: Q4.3 (S), Q6.3 (S), Q7.3 (S), R109.1, R110.1, R111.1, SW2.3 (2), SW2.4 (2), SW3.3 (2), SW3.4 (2), SW4.3 (2), SW4.4 (2), SW5.3 (2), SW5.4 (2), TP96.1, TP97.1, TP98.1, TP99.1, TP100.1, TP101.1, TP102.1, TP103.1
LED_PWM_B: Q7.1 (G), R109.2, TP85.1
LED_PWM_G: Q6.1 (G), R110.2, TP84.1
LED_PWM_R: Q4.1 (G), R111.2, TP65.1
MON_SYS_BUS_CUR: TP55.1
unnamed: D11.1 (K), Q7.2 (D)
unnamed: D11.2 (K), Q6.2 (D)
unnamed: D11.3 (K), Q4.2 (D)
unnamed: D11.4 (A), R112.1
unnamed: D11.5 (A), R113.1
unnamed: D11.6 (A), R114.1
PS_POR_NRESET: TP64.1
PWR_3V3_SLP: TP54.1
PWR_DDR_1V5: TP92.1
PWR_DDR_1V5_EN: TP67.1
PWR_FPGA_1V0: TP91.1
PWR_FPGA_1V0_EN: TP66.1
PWR_FPGA_1V8: TP93.1
PWR_FPGA_1V8_EN: TP57.1
PWR_SYS_2V5: TP94.1
PWR_SYS_2V5_EN: TP68.1
PWR_SYS_3V3: R112.2, R113.2, R114.2, TP95.1
PWR_SYS_3V3_EN: TP59.1
PWR_SYS_5V: TP90.1
PWR_SYS_BUS: TP88.1
PWR_SYS_STANDBY: TP89.1
PWR_USBC_VBUS: TP44.1
PWR_USBC_VBUS_SW: TP43.1, TP87.1
PWR_VBAT_EN: TP73.1
SD_CD: TP52.1
SD_CLK: TP50.1
SD_CMD: TP51.1
SD_D0: TP46.1
SD_D1: TP47.1
SD_D2: TP48.1
SD_D3: TP49.1
SD_WP: TP53.1
SEN_PWR_EN: TP30.1
SEN_SPI_MISO: TP36.1
SEN_SPI_MOSI: TP33.1
SEN_SPI_NCS: TP35.1
SEN_SPI_SCLK: TP37.1
STP_NRESET: TP26.1
STP_SWCLK: TP25.1
STP_SWDIO: TP24.1
STP_UART_RX: TP23.1
STP_UART_TX: TP22.1
STUSB_ATTACH: TP62.1
STUSB_GPIO: TP60.1
STUSB_NINT: TP82.1
STUSB_ORI: TP83.1
STUSB_PD0: TP81.1
STUSB_PD1: TP61.1
STUSB_RESET: TP63.1
STUSB_SCL: TP69.1
STUSB_SDA: TP56.1
TFT_BL_PWM: TP42.1
TFT_LED_A: TP40.1
TFT_LED_K: TP41.1
USBC_ORI_SEL: TP80.1
WAKE_SIGNAL: TP86.1

Notes on the sheet:
UNCONTROLLED WHEN PRINTED
FPGA
STP
POWER
USB PD
BMS
CHARGER
MISC

Board: 8 copper layers, 123 parts (0 on the bottom side), 16 nets, no tracks yet.

## EAGLE design sensor.brd

Schematic: sensor.sch, sheet 1, TITLE

Notes on the sheet:
2022.07.12 - GSWDH LTD. IMAGE SENSOR MODULE REVISION 1.1.0 DESIGN BY GEORGE WALLER AT GSWDH LTD. GEORGEWALLER@GSWDH.CO.UK CONFIDENTIAL. FOR THE INTENDED READER ONLY.
UNCONTROLLED WHEN PRINTED

Schematic: sensor.sch, sheet 2

Parts:
C1, C3, C4, C5: 0.1uF 10V; 0402
C2: 2200pF 25V; 0402
CN2: TC2030; TC2030-MCP
CN3: FH52E-60S-0.5SH
R1, R2, R4, R24: 10k; 0603
U1: GMAX0505-DV; GMAX0505
U2: STM32L031G6; UFQPN28
U10: EMC1812T; DFN8

Connections:
GND: C1.1, C3.1, C4.1, C5.1, CN2.5 (GND), CN3.P1, CN3.P2, CN3.P3, CN3.P38, CN3.P39, CN3.P41, CN3.P42, CN3.P55, CN3.P56, CN3.P57, R4.1, U2.16 (VSS), U2.28 (VSS), U10.5 (GND), U10.EP (GND); also elsewhere on the board
unnamed: C2.2, U1.F3 (VDP), U10.2 (DXP)
unnamed: C2.1, U1.F4 (VDN), U10.3 (DXN)
PROC_BOOT0: R4.2, U2.27 (BOOT0)
PROC_NRESET: CN2.3 (!RESET), U2.4 (NRST)
PROC_PWR: C1.2, C3.2, C4.2, C5.2, CN2.1 (VCC), CN3.P54, R1.2, R2.2, R24.2, U2.1 (VDD), U2.5 (VDDA), U2.17 (VDD), U10.1 (VCC); also elsewhere on the board
PROC_SWCLK: CN2.4 (SWCLK), U2.22 (PA14)
PROC_SWDIO: CN2.2 (SWDIO), U2.21 (PA13)
SEN_B_D0_N: CN3.P28, U1.C15 (OUTB_N_0)
SEN_B_D0_P: CN3.P29, U1.B15 (OUTB_P_0)
SEN_B_D3_N: CN3.P26, U1.E13 (OUTB_N_3)
SEN_B_D3_P: CN3.P27, U1.D13 (OUTB_P_3)
SEN_B_D6_N: CN3.P33, U1.C12 (OUTB_N_6)
SEN_B_D6_P: CN3.P32, U1.B12 (OUTB_P_6)
SEN_B_D9_N: CN3.P25, U1.E10 (OUTB_N_9)
SEN_B_D9_P: CN3.P24, U1.D10 (OUTB_P_9)
SEN_B_D12_N: CN3.P20, U1.C9 (OUTB_N_12)
SEN_B_D12_P: CN3.P21, U1.B9 (OUTB_P_12)
SEN_B_D15_N: CN3.P16, U1.E7 (OUTB_N_15)
SEN_B_D15_P: CN3.P17, U1.D7 (OUTB_P_15)
SEN_B_D18_N: CN3.P15, U1.C6 (OUTB_N_18)
SEN_B_D18_P: CN3.P14, U1.B6 (OUTB_P_18)
SEN_B_D21_N: CN3.P11, U1.E4 (OUTB_N_21)
SEN_B_D21_P: CN3.P10, U1.D4 (OUTB_P_21)
SEN_CLK_IN: CN3.P46, U1.L14 (CLK_REF)
SEN_CLK_N: CN3.P5, U1.C3 (CLKN_OUT)
SEN_CLK_P: CN3.P4, U1.B3 (CLKP_OUT)
SEN_PWR_0V7_EN: U2.10 (PA4); also elsewhere on the board
SEN_PWR_1V3_EN: U2.11 (PA5); also elsewhere on the board
SEN_PWR_3V3_EN: U2.7 (PA1); also elsewhere on the board
SEN_PWR_3V6_EN: U2.8 (PA2); also elsewhere on the board
SEN_PWR_4V1_EN: U2.9 (PA3); also elsewhere on the board
SEN_PWR_EN: CN3.P40, U2.12 (PA6)
SEN_PWR_N1V3A_EN: U2.6 (PA0); also elsewhere on the board
SEN_SPI_!CS: CN3.P45, R2.1, U1.L13 (SPI_CS)
SEN_SPI_MISO: CN3.P44, U1.L12 (SPI_MISO)
SEN_SPI_MOSI: CN3.P43, U1.K12 (SPI_MOSI)
SEN_SPI_SCLK: CN3.P50, U1.J14 (SPI_SCLK)
SEN_SYS_!RESET: U1.K14 (!SYS_RST), U2.3 (PC15)
SEN_TDIG0: CN3.P52, U1.J12 (TDIG0)
SEN_TDIG1: CN3.P51, U1.J13 (TDIG1)
SEN_TEMP1: CN3.P47, U1.L15 (TEXP1)
SEN_TEXP0: CN3.P48, U1.L16 (TEXP0)
SEN_T_D0_N: CN3.P36, U1.R15 (OUTT_N_0)
SEN_T_D0_P: CN3.P37, U1.P15 (OUTT_P_0)
SEN_T_D3_N: CN3.P35, U1.N13 (OUTT_N_3)
SEN_T_D3_P: CN3.P34, U1.M13 (OUTT_P_3)
SEN_T_D6_N: CN3.P30, U1.R12 (OUTT_N_6)
SEN_T_D6_P: CN3.P31, U1.P12 (OUTT_P_6)
SEN_T_D9_N: CN3.P19, U1.N10 (OUTT_N_9)
SEN_T_D9_P: CN3.P18, U1.M10 (OUTT_P_9)
SEN_T_D12_N: CN3.P23, U1.R9 (OUTT_N_12)
SEN_T_D12_P: CN3.P22, U1.P9 (OUTT_P_12)
SEN_T_D15_N: CN3.P9, U1.N7 (OUTT_N_15)
SEN_T_D15_P: CN3.P8, U1.M7 (OUTT_P_15)
SEN_T_D18_N: CN3.P12, U1.R6 (OUTT_N_18)
SEN_T_D18_P: CN3.P13, U1.P6 (OUTT_P_18)
SEN_T_D21_N: CN3.P7, U1.N4 (OUTT_N_21)
SEN_T_D21_P: CN3.P6, U1.M4 (OUTT_P_21)
SEN_UART_RX: CN3.P49, U2.26 (PB7)
SEN_UART_TX: CN3.P53, U2.25 (PB6)
SYS_PWR_5V: CN3.P58, CN3.P59, CN3.P60; also elsewhere on the board
TMP_ALERT: R1.1, U10.6 (!ALERT)
TMP_I2C_SCL: U2.19 (PA9), U10.8 (SCL)
TMP_I2C_SDA: U2.20 (PA10), U10.7 (SDA)
TMP_THERM: R24.1, U10.4 (ADDR)

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Schematic: sensor.sch, sheet 3

Parts:
C6, C7, C15, C16, C18, C19, C44, C50: 22uF 6.3V; 1206
C8, C10, C12, C17, C21, C22, C23, C27, C28, C29, C33, C34, C35, C36, C41, C42, C43, C45, C51, C52, C54, C55, C56, C57, C58, C62: 4.7uF 6.3V; 0402
C9, C11, C13, C14, C20, C24, C25, C26, C30, C31, C32, C37, C38, C39, C40, C46, C47, C48, C49, C53, C59, C60, C61, C63, C64, C65, C66, C67, C68, C69, C70, C71, C72, C73, C74, C75, C76, C77, C78, C79, C80, C81, C82: 0.1uF 10V; 0402
R5: 0R; 0603
U1: GMAX0505-DV; GMAX0505

Connections:
GND: C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C56.1, C57.1, C58.1, C59.1, C60.1, C61.1, C62.1, C63.1, C64.1, C65.1, C66.1, C67.1, C68.1, C69.1, C70.1, C71.1, C72.1, C75.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, U1.A7 (GNDD), U1.A9 (GNDAD), U1.A11 (GNDA), U1.A13 (GNDA), U1.C16 (GNDAD), U1.E16 (GNDA)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; also elsewhere on the board
unnamed: C74.1, U1.E1 (VRCP)
unnamed: R5.1, U1.A4 (VPBP)
unnamed: C75.1, U1.P1 (VCLBN)
unnamed: C76.1, U1.M1 (VPBN)
unnamed: C77.1, U1.G2 (VCLPCN)
unnamed: C78.1, U1.D1 (VREF)
unnamed: C79.1, U1.C2 (VRS)
unnamed: C80.1, U1.C1 (VRF)
unnamed: C81.1, U1.A3 (VCBN)
unnamed: C82.1, U1.D2 (VCIBP)
unnamed: C73.1, U1.E2 (VRBP)
PROC_PWR: C61.2, C71.2, U1.J16 (VDDIO), U1.K13 (VDDIO); also elsewhere on the board
SEN_PWR_0V7: C50.2, C58.2, C68.2, U1.M17 (VDDCL); also elsewhere on the board
SEN_PWR_1V3A: C15.2, C18.2, C21.2, C24.2, C27.2, C30.2, C33.2, C37.2, C41.2, C46.2, C54.2, C64.2, U1.A10 (VDD13AD), U1.C17 (VDD13AD), U1.D16 (VDD13AD), U1.J2 (VDD13AD), U1.T7 (VDD13AD), U1.T13 (VDD13AD); also elsewhere on the board
SEN_PWR_1V3D: C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C14.2, C17.2, C20.2, C23.2, C26.2, C29.2, C32.2, C35.2, C39.2, C43.2, C48.2, C56.2, C66.2, U1.A8 (VDD13D), U1.F16 (VDD13D), U1.G6 (VDD13D), U1.H2 (VDD13D), U1.H16 (VDD13D), U1.J6 (VDD13D), U1.K2 (VDD13D), U1.P17 (VDD13D), U1.T5 (VDD13D), U1.T11 (VDD13D); also elsewhere on the board
SEN_PWR_3V3A: C13.2, C16.2, C19.2, C22.2, C25.2, C28.2, C31.2, C34.2, C38.2, C42.2, C47.2, C55.2, C65.2, C73.2, C74.2, C82.2, R5.2, U1.A5 (VDD33A), U1.A12 (VDD33A), U1.A15 (VDD33A), U1.F1 (VDD33A), U1.G1 (VDD33A), U1.K16 (VDD33A), U1.L2 (VDD33A), U1.L6 (VDD33A), U1.M16 (VDD33A), U1.T9 (VDD33A); also elsewhere on the board
SEN_PWR_3V6: C36.2, C40.2, C45.2, C52.2, C53.2, C60.2, C62.2, C70.2, C72.2, U1.A14 (VDDPIX), U1.G17 (VTXH), U1.J17 (VTXH), U1.N17 (VDDPIX), U1.T15 (VDDPIX); also elsewhere on the board
SEN_PWR_4V1: C49.2, C57.2, C67.2, U1.E17 (VG_RSTH), U1.L17 (VG_RSTH); also elsewhere on the board
SEN_PWR_N1V3A: C44.2, C51.2, C59.2, C63.2, C69.2, U1.D17 (VGRSTL), U1.F17 (VTXL), U1.H17 (VTXL); also elsewhere on the board

Notes on the sheet:
UNCONTROLLED WHEN PRINTED
VDDIO 1ms (min) VDD13AD+VDD13D 1ms (min) VDD33A 1ms (min) Supply Array (VTXL etc.) 1ms (min) SYS_RST_N
Supply Voltage (V) Peak Current (mA) VDD33A 3.3 80 VDD13D 1.3 250 VDDIO 3.3 3 VDD13AD 1.3 160 VG_RSTH 4.1 25 VDDPIX 3.6 85 VDDCL 0.7 10 VTXH 3.6 75 VTXL -1.3 60 VGRSTL -1.3 15
