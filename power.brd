# Repository gswdh/CameraElectronics (continued)

## EAGLE design sensor.brd (continued)

Schematic: sensor.sch, sheet 4

Parts:
C83, C84, C85, C86, C94, C95, C96, C97: 4.7uF 10V; 0603
C87: 10uF 50V; 1210
C88: 2.2uF 10V; 0603
C89, C90, C91, C92: 10000pF 16V; 0402
C93, C98: 22uF 10V; 1206
C99, C100, C104: 22uF 6.3V; 1206
C101, C102: 10uF 10V; 1206
C103: 0.1uF 16V; 0603
C105, C106: 1uF 10V; 0603
FB1: 150R 100MHz; 1206
L1: 1uH; 1008
MECH1, MECH2, MECH3, MECH4: 6mm x 3mm; MOUNTHOLE_6X3
R6, R7, R8, R9, R10, R21: 10k; 0603
R11: 12k; 0603
R12: 2k; 0603
R13: 6.2k; 0603
R14: 36k; 0603
R15, R17, R20: 15k; 0603
R16: 75k; 0603
R18: 68k; 0603
R19: 13k; 0603
R22: 3.9k; 0603
R23: 100k; 0603
U3: MP2148; QFN6
U4, U5, U6, U7: MAX25300B; DFN8
U8: LM2662; SO8
U9: MAX1735; SOT23-5

Connections:
GND: C83.1, C84.1, C85.1, C86.1, C87.1, C88.1, C89.1, C90.1, C91.1, C92.1, C94.1, C95.1, C96.1, C97.1, C99.1, C100.1, C101.1, C102.1, C103.1, C104.1, C105.2, C106.2, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R13.1, R15.1, R17.1, R19.1, R21.1, R23.2, U3.2 (GND), U4.2 (GND), U4.4 (GS), U4.EP (GND), U5.2 (GND), U5.4 (GS), U5.EP (GND), U6.2 (GND), U6.4 (GS), U6.EP (GND), U7.2 (GND), U7.4 (GS), U7.EP (GND), U8.3 (GND), U8.6 (LV), U9.1 (GND); also elsewhere on the board
unnamed: L1.1, U3.4 (SW)
unnamed: R19.2, R20.1, U3.1 (FB)
unnamed: R22.2, R23.1, U9.4 (FB)
unnamed: C92.2, U7.7 (BYP)
unnamed: C93.2, C98.2, U8.2 (C+)
unnamed: C93.1, C98.1, U8.4 (C-)
unnamed: C91.2, U6.7 (BYP)
unnamed: R17.2, R18.1, U7.6 (FB)
unnamed: R15.2, R16.1, U6.6 (FB)
unnamed: C90.2, U5.7 (BYP)
unnamed: R13.2, R14.1, U5.6 (FB)
unnamed: C89.2, U4.7 (BYP)
unnamed: R11.2, R12.1, U4.6 (FB)
SEN_PWR_0V7: C94.2, R12.2, U4.8 (VOUT); also elsewhere on the board
SEN_PWR_0V7_EN: R7.2, U4.3 (EN); also elsewhere on the board
SEN_PWR_1V3A: C103.2, C104.2, FB1.2; also elsewhere on the board
SEN_PWR_1V3D: C101.2, C102.2, FB1.1, L1.2, R20.2, U3.6 (OUT); also elsewhere on the board
SEN_PWR_1V3_EN: R6.2, U3.5 (EN); also elsewhere on the board
SEN_PWR_3V3A: C97.2, R18.2, U7.8 (VOUT); also elsewhere on the board
SEN_PWR_3V3_EN: R10.2, U7.3 (EN); also elsewhere on the board
SEN_PWR_3V6: C96.2, R16.2, U6.8 (VOUT); also elsewhere on the board
SEN_PWR_3V6_EN: R9.2, U6.3 (EN); also elsewhere on the board
SEN_PWR_4V1: C95.2, R14.2, U5.8 (VOUT); also elsewhere on the board
SEN_PWR_4V1_EN: R8.2, U5.3 (EN); also elsewhere on the board
SEN_PWR_N1V3A: C106.1, R22.1, U9.5 (VOUT); also elsewhere on the board
SEN_PWR_N1V3A_EN: R21.2, U9.3 (EN); also elsewhere on the board
SEN_PWR_N5V0: C99.2, C100.2, C105.1, U8.5 (VOUT), U9.2 (VIN)
SYS_PWR_5V: C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, U3.3 (VIN), U4.1 (VIN), U5.1 (VIN), U6.1 (VIN), U7.1 (VIN), U8.8 (VIN); also elsewhere on the board

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Board: 6 copper layers, 40.0 x 50.0 mm, 147 parts (5 on the bottom side), 98 nets.

## EAGLE design interface.brd

Schematic: interface.sch, sheet 1, TITLE

Notes on the sheet:
2021.10.18 - GSWDH LTD. IMAGE SENSOR INTERFACE REVISION 1.0.0 DESIGN BY GEORGE WALLER AT GSWDH LTD. GEORGEWALLER@GSWDH.CO.UK CONFIDENTIAL. FOR THE INTENDED READER ONLY.
UNCONTROLLED WHEN PRINTED

Schematic: interface.sch, sheet 2, SENSOR

Parts:
C1: 0.1uF 16V; 0603
C7, C13: 10uF 10V; 1206
C36: 100pF 25V; 0603
CN1, CN2: 61083-103400LF
L3: 2.2uH 3A; IFSC-1515AH-01
R1, R3: 10k; 0603
R2: 39.2k; 0603
R6: 475k; 0603
R7, R23, R25: 1.5k; 0603
R9, R24, R26: 680R; 0603
R10: 150k; 0603
R22: 10R; 0603
U1: TLV3201; SOT23-5
U7: PAM2312; SOT23-5

Connections:
!CARRIER_SRST: CN1.6
!INIT: CN2.9
DXN_0_N: CN1.100
DXP_0_P: CN1.98
EVF_LVDS_CLK0_N: CN2.26; also elsewhere on the board
EVF_LVDS_CLK0_P: CN2.24; also elsewhere on the board
EVF_LVDS_CLK1_N: CN2.47; also elsewhere on the board
EVF_LVDS_CLK1_P: CN2.49; also elsewhere on the board
EVF_LVDS_D0_N: CN2.20; also elsewhere on the board
EVF_LVDS_D0_P: CN2.18; also elsewhere on the board
EVF_LVDS_D1_N: CN2.30; also elsewhere on the board
EVF_LVDS_D1_P: CN2.32; also elsewhere on the board
EVF_LVDS_D2_N: CN2.35; also elsewhere on the board
EVF_LVDS_D2_P: CN2.37; also elsewhere on the board
EVF_LVDS_D7_N: CN2.61; also elsewhere on the board
EVF_LVDS_D7_P: CN2.63; also elsewhere on the board
EVF_LVDS_D8_N: CN2.43; also elsewhere on the board
EVF_LVDS_D8_P: CN2.41; also elsewhere on the board
EVF_LVDS_D9_N: CN2.53; also elsewhere on the board
EVF_LVDS_D9_P: CN2.55; also elsewhere on the board
EVF_PWR_1V8_EN: CN2.13; also elsewhere on the board
EVF_PWR_10V_EN: CN1.81; also elsewhere on the board
EVF_SPI_!CS: R25.2, R26.2; also elsewhere on the board
EVF_SPI_MISO: R22.2; also elsewhere on the board
EVF_SPI_MOSI: R23.2, R24.2; also elsewhere on the board
EVF_SPI_SCLK: R7.2, R9.2; also elsewhere on the board
FPGA_DONE: CN1.8
FPGA_EVF_SPI_!CS: CN2.25, R26.1
FPGA_EVF_SPI_MISO: CN2.23, R22.1
FPGA_EVF_SPI_MOSI: CN2.19, R24.1
FPGA_EVF_SPI_SCLK: CN2.17, R9.1
FPGA_EVF_SYS_!RESET: CN2.29; also elsewhere on the board
FPGA_VBATT: CN1.7
FPGA_VCCO_EN: CN2.10, R1.2, U1.3 (+)
GND: C1.2, C7.1, C13.1, CN1.15, CN1.16, CN1.21, CN1.22, CN1.27, CN1.28, CN1.33, CN1.34, CN1.39, CN1.40, CN1.45, CN1.46, CN1.51, CN1.52, CN1.65, CN1.66, CN1.71, CN1.72, CN1.77, CN1.85, CN1.86, CN1.95, CN1.96, CN2.15, CN2.16, CN2.21, CN2.22, CN2.27, CN2.28, CN2.33, CN2.34, CN2.39, CN2.40, CN2.45, CN2.46, CN2.51, CN2.52, CN2.65, CN2.66, CN2.71, CN2.72, CN2.77, CN2.85, CN2.86, CN2.91, CN2.92, R1.1, R3.1, R7.1, R10.1, R23.1, R25.1, U1.2 (GND), U7.2 (GND); also elsewhere on the board
JTAG_TCK: CN1.1
JTAG_TDI: CN1.4
JTAG_TDO: CN1.3
JTAG_TMS: CN1.2
unnamed: R2.1, R3.2, U1.4 (-)
unnamed: L3.1, U7.3 (SW)
unnamed: C36.1, R6.1, R10.2, U7.5 (FB)
PG_MODULE: CN2.11
PMOD_D0: CN2.1
PMOD_D1: CN2.2
PMOD_D2: CN2.3
PMOD_D3: CN2.4
PMOD_D4: CN2.5
PMOD_D5: CN2.6
PMOD_D6: CN2.7
PMOD_D7: CN2.8
PWR_ENABLE: CN1.5
SEN_B_D0_N: CN1.84; also elsewhere on the board
SEN_B_D0_P: CN1.82; also elsewhere on the board
SEN_B_D3_N: CN1.76; also elsewhere on the board
SEN_B_D3_P: CN1.74; also elsewhere on the board
SEN_B_D6_N: CN1.63; also elsewhere on the board
SEN_B_D6_P: CN1.61; also elsewhere on the board
SEN_B_D9_N: CN1.70; also elsewhere on the board
SEN_B_D9_P: CN1.68; also elsewhere on the board
SEN_B_D12_N: CN1.56; also elsewhere on the board
SEN_B_D12_P: CN1.54; also elsewhere on the board
SEN_B_D15_N: CN1.44; also elsewhere on the board
SEN_B_D15_P: CN1.42; also elsewhere on the board
SEN_B_D18_N: CN1.38; also elsewhere on the board
SEN_B_D18_P: CN1.36; also elsewhere on the board
SEN_B_D21_N: CN1.26; also elsewhere on the board
SEN_B_D21_P: CN1.24; also elsewhere on the board
SEN_CLK_IN: CN1.23; also elsewhere on the board
SEN_CLK_N: CN1.49; also elsewhere on the board
SEN_CLK_P: CN1.47; also elsewhere on the board
SEN_PWR_EN: CN1.11; also elsewhere on the board
SEN_SPI_!CS: CN1.19; also elsewhere on the board
SEN_SPI_MISO: CN1.17; also elsewhere on the board
SEN_SPI_MOSI: CN1.13; also elsewhere on the board
SEN_SPI_SCLK: CN1.35; also elsewhere on the board
SEN_SYS_!RESET: CN1.31; also elsewhere on the board
SEN_TDIG0: CN1.41; also elsewhere on the board
SEN_TDIG1: CN1.37; also elsewhere on the board
SEN_TEMP1: CN1.25; also elsewhere on the board
SEN_TEMP_SPI_!CS: CN1.43; also elsewhere on the board
SEN_TEXP0: CN1.29; also elsewhere on the board
SEN_T_D0_N: CN1.75; also elsewhere on the board
SEN_T_D0_P: CN1.73; also elsewhere on the board
SEN_T_D3_N: CN1.69; also elsewhere on the board
SEN_T_D3_P: CN1.67; also elsewhere on the board
SEN_T_D6_N: CN1.55; also elsewhere on the board
SEN_T_D6_P: CN1.53; also elsewhere on the board
SEN_T_D9_N: CN1.50; also elsewhere on the board
SEN_T_D9_P: CN1.48; also elsewhere on the board
SEN_T_D12_N: CN1.64; also elsewhere on the board
SEN_T_D12_P: CN1.62; also elsewhere on the board
SEN_T_D15_N: CN1.20; also elsewhere on the board
SEN_T_D15_P: CN1.18; also elsewhere on the board
SEN_T_D18_N: CN1.32; also elsewhere on the board
SEN_T_D18_P: CN1.30; also elsewhere on the board
SEN_T_D21_N: CN1.14; also elsewhere on the board
SEN_T_D21_P: CN1.12; also elsewhere on the board
SYS_PWR_2V5: C7.2, C36.2, CN1.78, CN1.79, CN1.80, CN2.78, CN2.79, CN2.80, L3.2, R6.2; also elsewhere on the board
SYS_PWR_5V: C1.1, C13.2, CN1.57, CN1.58, CN1.59, CN1.60, CN2.12, CN2.57, CN2.58, CN2.59, CN2.60, R2.2, U1.5 (VCC), U7.4 (VIN); also elsewhere on the board
SYS_VCCO_EN: U1.1 (VOUT), U7.1 (EN)
VN_0_P: CN1.99
VP_0_P: CN1.97

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Schematic: interface.sch, sheet 3

Parts:
C3, C5: 10uF 10V; 1206
C6: 100pF 25V; 0603
C8, C14: 10uF 16V; 1206
C12: 330pF 50V; 0603
C15: 10000pF 16V; 0603
C16: 1800pF 50V; 0603
C17: 10uF 25V; 1206
C18: 68pF 100V; 0603
C19, C24, C28: 0.1uF 16V; 0603
C20, C21, C25, C26, C29, C30, C31, C32, C33: 0.1uF 10V; 0402
C22, C27: 4.7uF 25V; 0603
C23: 1uF 16V; 0603
C34, C35: 22uF 10V; 1206
CN3: FH52E-60S-0.5SH
CN4, CN6: PCB Tab; PCB_TAB_SMALL
CN5: 61 PIN 0.2mm FFC; 046866761000846+
D1: PMEG4010BEA; SOD-323
D2, D3, D4: B360A-13-F; DO214AC
L1: 10uH 1.3A; IFSC-1515AH-01
L2: 22uH; ECS-MPIL0630
L5: 2.2uH 3A; IFSC-1515AH-01
MECH1, MECH2, MECH3, MECH4, MECH5, MECH6: 6mm x 3mm; MOUNTHOLE_6X3
Q1: 2N7002; SOT23-3
R4: 200k; 0603
R5: 100k; 0603
R8, R14, R19, R20, R21: 10k; 0603
R11: 95.3k; 0603
R12: 13.3k; 0603
R13: 47.5k; 0603
R15: 21k; 0603
R18: 1.91k; 0603
U3: PAM2312; SOT23-5
U5: LM2731X; SOT23-5
U6: TPS54233D; SO8

Connections:
EVF_LVDS_CLK0_N: CN5.20; also elsewhere on the board
EVF_LVDS_CLK0_P: CN5.19; also elsewhere on the board
EVF_LVDS_CLK1_N: CN5.48; also elsewhere on the board
EVF_LVDS_CLK1_P: CN5.47; also elsewhere on the board
EVF_LVDS_D0_N: CN5.22; also elsewhere on the board
EVF_LVDS_D0_P: CN5.21; also elsewhere on the board
EVF_LVDS_D1_N: CN5.24; also elsewhere on the board
EVF_LVDS_D1_P: CN5.23; also elsewhere on the board
EVF_LVDS_D2_N: CN5.26; also elsewhere on the board
EVF_LVDS_D2_P: CN5.25; also elsewhere on the board
EVF_LVDS_D7_N: CN5.42; also elsewhere on the board
EVF_LVDS_D7_P: CN5.41; also elsewhere on the board
EVF_LVDS_D8_N: CN5.44; also elsewhere on the board
EVF_LVDS_D8_P: CN5.43; also elsewhere on the board
EVF_LVDS_D9_N: CN5.46; also elsewhere on the board
EVF_LVDS_D9_P: CN5.45; also elsewhere on the board
EVF_PWR_1V8: C3.2, C6.2, C25.2, C30.2, C31.1, CN5.5, CN5.14, CN5.17, CN5.31, CN5.36, CN5.49, CN5.51, L5.2, R4.2, R21.2
EVF_PWR_1V8_EN: U3.1 (EN); also elsewhere on the board
EVF_PWR_10V: C12.2, C14.2, C19.2, C28.2, CN5.3, CN5.53, D1.K, R11.2
EVF_PWR_10V_EN: R8.2, U5.4 (SHDN); also elsewhere on the board
EVF_SPI_!CS: CN5.8; also elsewhere on the board
EVF_SPI_MISO: CN5.11; also elsewhere on the board
EVF_SPI_MOSI: CN5.10; also elsewhere on the board
EVF_SPI_SCLK: CN5.9; also elsewhere on the board
EVF_SYS_!RESET: C29.2, CN5.15, Q1.2 (D), R21.1
EVF_VCAL: C20.2, CN5.55
EVF_VCATH: CN5.1
EVF_VCCP: C22.1, C27.1, CN5.2, CN5.60
EVF_VG0: C21.2, CN5.57
EVF_VG255: C26.1, CN5.56
EVF_VGC: C32.1, CN5.54
EVF_VOFS: C33.1, CN5.58
EVF_VREF: C23.2, CN5.59
FPGA_EVF_SYS_!RESET: Q1.1 (G), R20.1; also elsewhere on the board
GND: C3.1, C5.1, C8.1, C14.1, C15.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.2, C23.1, C25.1, C26.2, C27.2, C28.1, C29.1, C30.1, C31.2, C32.2, C33.2, C34.1, C35.1, CN3.P1, CN3.P2, CN3.P3, CN3.P38, CN3.P39, CN3.P41, CN3.P42, CN3.P55, CN3.P56, CN3.P57, CN5.4, CN5.6, CN5.7, CN5.13, CN5.16, CN5.27, CN5.28, CN5.29, CN5.30, CN5.32, CN5.33, CN5.34, CN5.35, CN5.37, CN5.38, CN5.39, CN5.40, CN5.50, CN5.52, CN5.61, CN6.1, D3.A, D4.A, Q1.3 (S), R5.1, R8.1, R12.1, R14.1, R15.1, R18.1, R20.2, U3.2 (GND), U5.2 (GND), U6.7 (GND); also elsewhere on the board
unnamed: C24.1, D4.K, L2.1, U6.8 (PH)
unnamed: C24.2, U6.1 (BOOT)
unnamed: C17.2, D2.K, D3.K, R13.2, U6.2 (VIN)
unnamed: R13.1, R14.2, U6.3 (EN)
unnamed: R18.2, R19.1, U6.5 (VSNS)
unnamed: C16.2, C18.2, U6.6 (COMP)
unnamed: C16.1, R15.2
unnamed: C15.2, U6.4 (SS)
unnamed: CN4.1, D2.A
unnamed: L5.1, U3.3 (SW)
unnamed: C6.1, R4.1, R5.2, U3.5 (FB)
unnamed: D1.A, L1.2, U5.1 (SW)
unnamed: C12.1, R11.1, R12.2, U5.3 (FB)
SEN_B_D0_N: CN3.P28; also elsewhere on the board
SEN_B_D0_P: CN3.P29; also elsewhere on the board
SEN_B_D3_N: CN3.P26; also elsewhere on the board
SEN_B_D3_P: CN3.P27; also elsewhere on the board
SEN_B_D6_N: CN3.P33; also elsewhere on the board
SEN_B_D6_P: CN3.P32; also elsewhere on the board
SEN_B_D9_N: CN3.P25; also elsewhere on the board
SEN_B_D9_P: CN3.P24; also elsewhere on the board
SEN_B_D12_N: CN3.P20; also elsewhere on the board
SEN_B_D12_P: CN3.P21; also elsewhere on the board
SEN_B_D15_N: CN3.P16; also elsewhere on the board
SEN_B_D15_P: CN3.P17; also elsewhere on the board
SEN_B_D18_N: CN3.P15; also elsewhere on the board
SEN_B_D18_P: CN3.P14; also elsewhere on the board
SEN_B_D21_N: CN3.P11; also elsewhere on the board
SEN_B_D21_P: CN3.P10; also elsewhere on the board
SEN_CLK_IN: CN3.P46; also elsewhere on the board
SEN_CLK_N: CN3.P5; also elsewhere on the board
SEN_CLK_P: CN3.P4; also elsewhere on the board
SEN_PWR_EN: CN3.P40; also elsewhere on the board
SEN_SPI_!CS: CN3.P45; also elsewhere on the board
SEN_SPI_MISO: CN3.P44; also elsewhere on the board
SEN_SPI_MOSI: CN3.P43; also elsewhere on the board
SEN_SPI_SCLK: CN3.P50; also elsewhere on the board
SEN_SYS_!RESET: CN3.P49; also elsewhere on the board
SEN_TDIG0: CN3.P52; also elsewhere on the board
SEN_TDIG1: CN3.P51; also elsewhere on the board
SEN_TEMP1: CN3.P47; also elsewhere on the board
SEN_TEMP_SPI_!CS: CN3.P53; also elsewhere on the board
SEN_TEXP0: CN3.P48; also elsewhere on the board
SEN_T_D0_N: CN3.P36; also elsewhere on the board
SEN_T_D0_P: CN3.P37; also elsewhere on the board
SEN_T_D3_N: CN3.P35; also elsewhere on the board
SEN_T_D3_P: CN3.P34; also elsewhere on the board
SEN_T_D6_N: CN3.P30; also elsewhere on the board
SEN_T_D6_P: CN3.P31; also elsewhere on the board
SEN_T_D9_N: CN3.P19; also elsewhere on the board
SEN_T_D9_P: CN3.P18; also elsewhere on the board
SEN_T_D12_N: CN3.P23; also elsewhere on the board
SEN_T_D12_P: CN3.P22; also elsewhere on the board
SEN_T_D15_N: CN3.P9; also elsewhere on the board
SEN_T_D15_P: CN3.P8; also elsewhere on the board
SEN_T_D18_N: CN3.P12; also elsewhere on the board
SEN_T_D18_P: CN3.P13; also elsewhere on the board
SEN_T_D21_N: CN3.P7; also elsewhere on the board
SEN_T_D21_P: CN3.P6; also elsewhere on the board
SYS_PWR_2V5: CN3.P54; also elsewhere on the board
SYS_PWR_5V: C5.2, C8.2, C34.2, C35.2, CN3.P58, CN3.P59, CN3.P60, L1.1, L2.2, R19.2, U3.4 (VIN), U5.5 (VIN); also elsewhere on the board

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Board: 4 copper layers, 70.0 x 120.0 mm, 81 parts (4 on the bottom side), 104 nets.

## EAGLE design camera_main_sch_brd.brd

Schematic: camera_main_sch_brd.sch, sheet 2, FPGA

Parts:
U1: 10CL016YF484C6G; FBGA484

Schematic: camera_main_sch_brd.sch, sheet 3, MCU

Parts:
CN7: uSD; 114-00841-68
R33, R34, R35, R36, R37, R38: 10k; 0603

Connections:
3V3: CN7.4 (VCC), R33.2, R34.2, R35.2, R36.2, R37.2, R38.2; also elsewhere on the board
GND: CN7.6 (GND), CN7.MNT1 (GND), CN7.MNT2 (GND), CN7.MNT3 (GND), CN7.MNT4 (GND); also elsewhere on the board
SD_CLK: CN7.5 (CLK), R38.1
SD_CMD: CN7.3 (C/R), R37.1
SD_D0: CN7.7 (D0), R36.1
SD_D1: CN7.8 (D1), R35.1
SD_D2: CN7.1 (D2), R34.1
SD_D3: CN7.2 (D3), R33.1

Schematic: camera_main_sch_brd.sch, sheet 5, SYSTEM_POWER

Parts:
C1, C25: 47nF 16V; 0603
C18, C19, C49, C50: 22uF 10V; 1206
C26, C30, C35, C39, C40, C48: 100nF 16V; 0603
C27, C33, C51: 10nF 50V; 0603
C28, C34, C36, C37: 47uF 25V; 1206
C29, C45, C46, C47: 1uF 25V; 0603
C31: 10nF 250V; 0603
C32: 1nF 50V; 0603
C38: 10uF 50V; 1210
C52: 2.2nF 50V; 0402
C53: 1uF 50V; 1206
CN1: USB C CON; 12401832E402A
CN6: NO FIT; 2PIN_HEADER
CN8: NO FIT; TSM-103-DV
D1, D5, D6: B0540W; SOD-123
D2: B360A-13-F; DO214AC
D7, D8: PESD5Z5.0; SC-79
D9: 20V TVS; DO214AC
L1: 4.7uH 8.3A; ETQP4M***KVK
L3: 22uH 3.7A; SRR1260
Q2: SI7489DP; SO8_POWERPAK
R14, R22: 0R01; 1206
R15, R16, R23, R24: 33R; 0603
R17, R21, R43: 20k; 0603
R18: 33k; 0603
R20, R39, R40, R41, R47: 10k; 0603
R25: 1.0M; 0603
R42: 2.0k; 0603
R44: 1.0k; 0603
R45: 100k; 0603
R46: 22k; 0603
U3: STM32L431RBT; QFP64_SMALL
U7: ACT2861; QFN32-ACT2861
U8: USBLC6-2SC6; SOT23-6
U12: TPS54233D; SO8
U13: FT230X; SSOP16-4MM
U14: 3.3V BUCK; TI_MICROSIP_10
U15: STUSB4500; QFN24

Connections:
3V3: C39.2, C40.2, R25.2, U7.8 (!OTG), U13.3 (VCCIO), U13.10 (3V3OUT), U13.11 (!RESET), U13.12 (VCC); also elsewhere on the board
3V3_SLP: C18.2, C19.2, CN8.1, R39.2, U3.1 (VBAT), U3.13 (VDDA), U3.19 (VDD), U3.32 (VDD), U3.48 (VDD), U3.64 (VDD), U14.6 (VOUT), U14.7 (FB)
5V: C49.2, C50.2, L3.2, R41.2
ACT_!IRQ: U7.10 (!IRQ)
ACT_ICOMP: C31.2, C32.2, U7.31 (ICOMP/GPIO)
ACT_SHIPM: R25.1, U7.9 (SHIPM)
BUS_I2C_SCL: U7.7 (SCL)
BUS_I2C_SDA: U7.6 (SDA)
GND: C18.1, C19.1, C27.1, C28.1, C29.1, C30.1, C32.1, C33.1, C34.1, C36.1, C37.1, C38.1, C39.1, C40.1, C45.1, C46.1, C47.1, C49.1, C50.1, C51.1, C53.1, CN1.A1 (GND), CN1.A12 (GND), CN1.B1 (GND), CN1.B12 (GND), CN1.P$1 (SHELL), CN1.P$2 (SHELL), CN1.P$3 (SHELL), CN1.P$4 (SHELL), CN1.P$5 (SHELL), CN1.P$6 (SHELL), CN1.P$7 (SHELL), CN1.P$8 (SHELL), CN1.P$9 (SHELL), CN1.P$10 (SHELL), CN1.P$11 (SHELL), CN1.P$12 (SHELL), CN1.P$13 (SHELL), CN1.P$14 (SHELL), CN1.P$15 (SHELL), CN1.P$16 (SHELL), CN1.P$17 (SHELL), CN1.P$18 (SHELL), CN1.P$19 (SHELL), CN1.P$20 (SHELL), CN1.P$21 (SHELL), CN1.P$22 (SHELL), CN1.P$23 (SHELL), CN1.P$24 (SHELL), CN1.P$25 (SHELL), CN1.P$26 (SHELL), CN1.P$27 (SHELL), CN1.P$28 (SHELL), CN6.2, CN8.6, D2.A, D6.A, D7.A, D8.A, D9.A, R17.1, R18.1, R20.1, R21.1, R40.1, R42.1, R43.1, R47.1, U3.12 (VSSA), U3.18 (VSS), U3.31 (VSS), U3.47 (VSS), U3.63 (VSS), U7.1 (AGND), U7.5 (PGND), U7.20 (PGND), U7.28 (!CHG), U7.32 (EN_CHG), U7.EP (PGND), U8.2 (GND)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; also elsewhere on the board
MP1_UART_RX: U13.1 (TXD)
MP1_UART_TX: U13.4 (RXD)
unnamed: C1.1, U7.25 (HSB1)
unnamed: C25.1, U7.15 (HSB2)
unnamed: C1.2, L1.1, U7.21 (SW1), U7.22 (SW1), U7.34 (SW1)
unnamed: C29.2, U7.4 (VREG)
unnamed: C25.2, L1.2, U7.18 (SW2), U7.19 (SW2), U7.33 (SW2)
unnamed: C27.2, C28.2, R14.2, R15.1, U7.23 (VIN), U7.24 (VIN), U7.35 (VIN)
unnamed: C26.1, R15.2, U7.27 (ISRN)
unnamed: C26.2, R16.2, U7.26 (ISRP)
unnamed: C30.2, U7.3 (INTBP)
unnamed: R17.2, U7.11 (OLIM)
unnamed: R18.2, U7.29 (ILIM)
unnamed: CN6.1, R20.2, U7.2 (TH)
unnamed: C31.1, R21.2
unnamed: C33.2, C34.2, R22.1, R23.2, U7.16 (VBAT), U7.17 (VBAT)
unnamed: C35.1, R23.1, U7.14 (OSRP)
unnamed: C35.2, R24.1, U7.13 (OSRN)
unnamed: C38.2, D1.K, D5.K, D6.K, U14.3 (VIN), U14.4 (EN)
unnamed: C48.1, U12.1 (BOOT)
unnamed: C48.2, D2.K, L3.1, U12.8 (PH)
unnamed: U8.3 (D-_IN), U13.9 (D-)
unnamed: U8.1 (D+_IN), U13.8 (D+)
unnamed: R41.1, R42.2, U12.5 (VSNS)
unnamed: C51.2, U12.4 (SS)
unnamed: R40.2, U3.60 (PH3-BOOT0)
unnamed: C52.1, R43.2
unnamed: C52.2, U12.6 (COMP)
unnamed: R44.1, U15.18 (VBUS_VS_DISCH)
unnamed: Q2.4 (G), R45.1, R46.2
unnamed: R46.1, U15.16 (VBUS_EN_SNK)
unnamed: C45.2, U15.23 (VREG_2V7)
unnamed: C46.2, U15.21 (VREG_1V2)
RAIL_5V_EN: R47.2, U12.3 (EN)
STM32_NRST: CN8.3, R39.1, U3.7 (NRST)
STM_SWCLK: CN8.4, U3.49 (PA14)
STM_SWDIO: CN8.5, U3.46 (PA13)
STUSB_!ALERT: U15.19 (!ALERT)
STUSB_ATTACH: U15.11 (ATTACH)
STUSB_GPIO: U15.15 (GPIO)
STUSB_ORI: U15.17 (A_B_SIDE)
STUSB_PD0: U15.20 (POWER_OK2)
STUSB_PD1: U15.14 (POWER_OK3)
STUSB_RESET: U15.6 (RESET)
STUSB_SCL: U15.7 (SCL)
STUSB_SDA: U15.8 (SDA)
USBC_CC1: CN1.A5 (CC1), D7.K, U15.1 (CC1DB), U15.2 (CC1)
USBC_CC2: CN1.B5 (CC2), D8.K, U15.4 (CC2), U15.5 (CC2DB)
USBC_USB_DM: CN1.A7 (D-), CN1.B7 (D-), U8.4 (D-OUT)
USBC_USB_DP: CN1.A6 (D+), CN1.B6 (D+), U8.6 (D+_OUT)
USBC_VBUS: C47.2, CN1.A4 (VBUS), CN1.A9 (VBUS), CN1.B4 (VBUS), CN1.B9 (VBUS), D5.A, D9.K (A1), Q2.1 (S), Q2.2 (S), Q2.3 (S), R44.2, R45.2, U15.24 (VDD)
VBAT: C37.2, C53.2, D1.A, R22.2, R24.2, U7.12 (VBATS), U12.2 (VIN)
VBUS_SWD: C36.2, Q2.5 (D), Q2.6 (D), Q2.7 (D), Q2.8 (D), Q2.PAD (D), R14.1, R16.1

Schematic: camera_main_sch_brd.sch, sheet 6, MECH

Parts:
MECH1, MECH2, MECH3, MECH4, MECH5, MECH6, MECH7, MECH8: 6mm x 3mm; MOUNTHOLE_6X3

Board: 4 copper layers, 123.5 x 123.5 mm, 84 parts (1 on the bottom side), 54 nets.

## Commit log

2020-05-19 Starting on the HW rev
2020-05-23 Progress, new names
2020-05-23 Thernet PHY added
2020-06-05 Progress
2020-06-10 Blocks are forming
2020-06-10 Pushed to fusion
2020-11-09 New main PCB started
2021-04-01 Added lots
2021-04-02 MCU power done
2021-04-09 UVC chip added
2021-04-12 New board outline
2021-04-19 Added section for USB memory
2021-04-23 USB 2.0 PHY Added
2021-04-23 Lots of bits
2021-04-25 Some bits
2021-04-25 Added a BMS
2021-04-25 EVF connector added
2021-04-29 Rearranged schematics
2021-04-29 Power rails for the sensor, done
2021-05-01 Changed BMS transistors
2021-05-03 Started on PSU for the sensor
2021-05-04 more work on the sensor supplies
2021-05-05 Rename some supplies
2021-05-05 Sensor circuitry done
2021-05-14 More PSU additions
2021-05-14 More PSU progress
2021-05-29 FT602 routed
2021-05-29 USB3320C routed
2021-05-30 FPGA and sensor PSUs routed
2021-06-01 More layout
2021-06-02 Diff pairs started
2021-06-02 EVF power routed
2021-10-16 Working on a sensor PCB
2021-10-17 Sensor PCB routed and DRC passes, needs review of layer stack and diff pairs
2021-10-17 LDO replaced for stock, BoM ordered
2021-10-18 Checked and ready for GERBERs
2021-11-13 Interface PCB started
2021-12-04 Interface PCB laid out. Needs thorough review, and FPGA pinout test
2022-04-06 Interface modified with in stock components
2022-07-31 Fixes for sensor PCB
2022-11-08 New more simple desing
2022-11-09 Lots of work
2022-11-09 DDR3 almost completed. PSU sequencing for the termination supply needs investigating. Termination resistors need to be set to the right values.
2022-11-10 New Zynq
2022-11-11 Schematic building progress
2022-11-11 New USB connector
2022-11-12 New PSU architecture
2022-11-13 General progress
2022-11-13 Starting to layout
2022-11-14 Progress on the layout
2022-11-14 initial sensor LVDS pairs run
2022-11-17 First DDR IC routed to FPGA roughl;y
2022-11-18 Another stab at memory routing
2022-11-21 DDR routed
2022-11-21 All components on the PCB
2022-11-22 Mech design and layout
2022-11-23 Moved to FT600 due to IO constraints
2022-11-23 Display FFC added back in
2022-11-23 Base FT600 laid out
2022-11-24 Nearly complete initial iteration
2022-11-24 More arwairs gone
2022-11-25 Low power MCU routed
2022-11-25 Wokring on connecting MIO
2022-11-26 Lots of routing
2022-11-26 First iteration done apart from switch location and wiring
2022-11-28 Need to add VCCO decoupling
2022-11-28 VCCO decups added
2022-12-02 FPGA wired up
2022-12-03 FT601 wired up
2022-12-03 First iteratio done
2022-12-05 Buttoms placed correctly
2022-12-05 DRC run
2022-12-05 BoMs removed
2022-12-11 Battery PCB done
2022-12-11 Renumber parts scr removed
2022-12-11 Interface and replacement PCBs removed
2022-12-14 debug board done
2022-12-14 Sensorboard reworked for correct connector orientation
2022-12-15 Test points added
2022-12-15 Fixed comp0onent idents
2023-04-07 New format working on
2023-05-14 Passing DRC
2023-05-31 PSS and FPGA connections reworked
2023-05-31 Corners rounded
2023-05-31 Display wired in
2023-06-01 1V8 PSU added
2023-06-02 Fixed LEDS, sensor clock location
2023-06-03 FPGA all on 1V8
2023-06-08 PSS boot flash added
2023-06-08 PSS boot config pins added. PCB passes DRC
2023-06-15 Buttons added
2023-06-20 Config pins fixed
2023-06-20 Shutter button fixed
2023-06-20 Extra mech holes
2023-06-23 Thumb button connected to wakeup, diff pair lengths fixed
2023-06-23 Silkscreen updated
2023-06-24 Small fixes to main
2023-06-24 PSS SPI boot FLASH connected to the correct pins
2023-06-25 Small bits
2023-07-01 More pin polanning
2023-07-03 Half the MIPI wired in
2023-07-04 MIPI high speed wired in, needs to be length matched
2023-07-04 Image sensor LVDS routed, needs length matching
2023-07-07 Neatly all components added. Need to connect, length match and verify
2023-07-13 More signals connected
2023-07-14 Routing nearly complete, boot pins todo
2023-07-14 DRC passes. Need to length match and review
2023-07-16 Decoupling added to FPGA
2023-07-17 Decoupling added to DDR3
2023-07-17 DDR3 length matched
2023-07-18 GMAX length matched
2023-07-18 EVF Length Matched
2023-07-19 Some pullups added
2023-07-22 Clock for FTDI fixed and SD status pins moved
2023-07-22 DDR3 FPGA VRP/N pins fixed, pullups on the buttons corrected
2023-07-24 Small changes
2023-07-25 Rev 1.0.0 ready for release
2023-07-25 Redundent files removed
2023-07-25 SRST added to the debug port
2023-07-25 Debug and power board ready for outputs
2023-07-26 Debug board is two layers
2023-07-26 Removed DS_Store
2023-08-14 Correct FPGA footprint routed. A lot of work to length match, optimise and review
2023-08-14 Passes DRC
2023-08-18 MIPI length matched DRC passes
2023-08-20 Image sensor length matched DRC passes
2023-08-20 button ADC is not attached to FPGA fabric
2023-08-21 Accomodations for sensor mount bracket
2023-08-21 Plane GND fills added
2023-09-01 Updated schematic front page
2023-09-01 Updated schematic front page on power
2023-09-01 Larger battery tabs and new mounting holes on power PCB
2023-09-01 Updated version number on main PCB
2023-10-23 Added extra decoupling to the PLL PSU
2023-10-23 CN6 routed to new location closes #22
2023-10-23 Display is now connected to FPGA logic Closes #21
2023-10-23 STUSB4500 now has pullups
2023-10-23 STUSB4500 corrected digikey order number
2023-10-23 STUSB4500 I2C orientation corrected and resistors added to facilitate reversing
2023-10-23 SPI fixed, FPGA LEDs fixed
2023-10-23 U22 now powered
2023-10-23 Power PCB connector now in correct orientation
2023-10-24 U10 and U8 regulators fixed
2023-10-24 USB connector rerouted
2023-10-24 Power PCB updated
2023-10-24 Fixed inverter fit status
2023-10-24 Fixed screen ribbon ori again and sorted PMC I2C lines
2023-10-24 DDR3 is rerouted, DRC passes
2023-10-28 Prepped for ultrascale
2023-11-04 Added FX3
2023-11-13 Revert prior to new image sensor
2023-11-20 Added ethernet and native USB 2.0
2023-11-20 Last GPIO signals to route
2023-11-20 Everything routed. Needs DRC and lots of review
2023-11-20 Top and bottom pours added, pushed to fusion
2023-11-21 Cleaned up schematic
2023-11-24 EVF connector now in the correct orientation. MIPI needs renaming and length matching
2023-11-24 MIPI length matched
2023-11-25 Adjusted PSS DEBUG UART Vio
2023-11-28 Planes implemented
2023-12-06 Fixed ETH RX CTL and CLK bug. Mved USB and WTH resets to PL
2023-12-07 BTN_THUMB connected directly to the PMC IO
2023-12-09 Ethernet PCB done and small bits to main PCB
2023-12-25 Push to fusion
2024-02-14 Removed some DRC errors
2024-02-14 Updated the dates
2024-02-27 Ready for release
2024-05-09 Addition of an ethernet adapter PCB
2024-09-16 Power PCB updated and ready for manufacture
2024-09-17 Added I2C test points
2024-11-18 New stuff
2025-05-26 started on power pcb
