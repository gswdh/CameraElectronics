# Repository gswdh/CameraElectronics (continued)

## EAGLE design main.brd (continued)

Parts:
C87, C89, C93: 2.2uF 10V; 0402
C88, C91, C92, C94, C95, C96, C97, C98, C99, C160, C161, C168, C169: 1uF 10V; 0402
C90: 4.7uF 6.3V; 0603
C145, C150: 2.2uF 10V; 0603
C146, C148: 22uF 10V; 1206
C147, C149: 22uF 6.3V; 1206
C151: 10uF 10V; 0603
C153: 820pF 25V; 0402
C157: 1000pF 10V; 0402
C158, C165: 0.1uF 10V; 0402
C159: NO FIT; 0603
CN4: FF0881SA1; CONN81_FF0881SA1_JAE
D8, D10: PMEG4010BEA; SOD-323
D11: 5V; SOD-323
L8: 10uH; SRN6045
Q3: 2N7002; SOT23-3
R81, R82, R88: 10k; 0402
R83: 56.2k; 0603
R84: 13.3k; 0603
U29: LM2663; SO8
U30: LM2731X; SOT23-5
U34: TPS22917; SOT23-6

Connections:
BUS_I2C_SCL: CN4.62
BUS_I2C_SDA: CN4.63
EVF_ELVDD: C89.2, CN4.4, CN4.77
EVF_MIPI_A_CLK_N: CN4.27; also elsewhere on the board
EVF_MIPI_A_CLK_P: CN4.26; also elsewhere on the board
EVF_MIPI_A_D0_N: CN4.24; also elsewhere on the board
EVF_MIPI_A_D0_P: CN4.23; also elsewhere on the board
EVF_MIPI_A_D1_N: CN4.30; also elsewhere on the board
EVF_MIPI_A_D1_P: CN4.29; also elsewhere on the board
EVF_MIPI_A_D2_N: CN4.33; also elsewhere on the board
EVF_MIPI_A_D2_P: CN4.32; also elsewhere on the board
EVF_MIPI_A_D3_N: CN4.21; also elsewhere on the board
EVF_MIPI_A_D3_P: CN4.20; also elsewhere on the board
EVF_MIPI_B_CLK_N: CN4.42; also elsewhere on the board
EVF_MIPI_B_CLK_P: CN4.41; also elsewhere on the board
EVF_MIPI_B_D0_N: CN4.39; also elsewhere on the board
EVF_MIPI_B_D0_P: CN4.38; also elsewhere on the board
EVF_MIPI_B_D1_N: CN4.45; also elsewhere on the board
EVF_MIPI_B_D1_P: CN4.44; also elsewhere on the board
EVF_MIPI_B_D2_N: CN4.48; also elsewhere on the board
EVF_MIPI_B_D2_P: CN4.47; also elsewhere on the board
EVF_MIPI_B_D3_N: CN4.36; also elsewhere on the board
EVF_MIPI_B_D3_P: CN4.35; also elsewhere on the board
EVF_NRESET: CN4.67
EVF_VCOM: C87.2, CN4.1, CN4.81, D11.K
EVF_VDD: C90.1, C168.1, CN4.7, CN4.51, CN4.52
GND: C87.1, C88.2, C89.1, C90.2, C91.2, C92.2, C93.1, C94.2, C95.2, C96.2, C97.2, C98.2, C99.2, C145.1, C147.1, C149.1, C150.1, C151.1, C158.1, C159.1, C160.2, C161.2, C165.1, C168.2, C169.2, CN4.5, CN4.6, CN4.8, CN4.12, CN4.13, CN4.14, CN4.15, CN4.19, CN4.22, CN4.25, CN4.28, CN4.31, CN4.34, CN4.37, CN4.40, CN4.43, CN4.46, CN4.49, CN4.53, CN4.54, CN4.59, CN4.64, CN4.65, CN4.71, CN4.72, CN4.73, D8.K, D11.A, Q3.3 (S), R82.1, R84.1, R88.1, U29.3 (GND), U29.6 (LV), U30.2 (GND), U34.2 (GND); also elsewhere on the board
unnamed: C94.1, CN4.50
unnamed: C91.1, CN4.9
unnamed: C95.1, CN4.57
unnamed: C96.1, CN4.58
unnamed: C99.1, CN4.68
unnamed: C98.1, CN4.69, D8.A
unnamed: C97.1, CN4.70
unnamed: C146.2, C148.2, U29.2 (C+)
unnamed: C146.1, C148.1, U29.4 (C-)
unnamed: Q3.2 (D), R81.1, U29.1 (FC(SD))
unnamed: D10.A, L8.2, U30.1 (SW)
unnamed: C153.1, R83.1, R84.2, U30.3 (FB)
unnamed: C157.1, U34.4 (CT)
PWR_EVF_AVDD: C92.1, C151.2, C153.2, C160.1, CN4.10, CN4.11, CN4.74, CN4.75, CN4.76, D10.K, R83.2
PWR_EVF_AVDD_EN: R88.2, U34.3 (EN)
PWR_EVF_AVEE: C88.1, C147.2, C149.2, C161.1, CN4.2, CN4.3, CN4.78, CN4.79, CN4.80, U29.5 (VOUT)
PWR_EVF_AVEE_EN: Q3.1 (G), R82.2
PWR_RAIL1: C150.2, C159.2, L8.1, U30.4 (SHDN), U30.5 (VIN), U34.6 (VOUT)
PWR_SYS_1V8: C93.2, C165.2, C169.1, CN4.17, CN4.18, CN4.55, CN4.56, CN4.66
PWR_SYS_5V: C145.2, C157.2, C158.2, R81.2, U29.8 (VIN), U34.1 (VIN); also elsewhere on the board

Notes on the sheet:
UNCONTROLLED WHEN PRINTED
ELVDD - OUTPUT VGMP - OUTPUT VREF1 - OUTPUT VGSP - OUTPUT VDD - OUTPUT MVDD - OUTPUT VREF2 - OUTPUT VREF3 - OUTPUT VCOM - OUTPUT // Power on sequence VDDI AVDD AVEE RESET

Parts:
C20: 10uF 25V; 1206
C21, C26, C42, C43: 47uF 25V; 1206
C22: 1nF 50V; 0603
C23, C25, C27, C29, C31, C35, C134, C135, C136: 0.1uF 10V; 0402
C24: 10nF 250V; 0603
C28, C41: 10nF 50V; 0603
C30, C32, C40: 100nF 16V; 0603
C33, C55, C56, C57: 1uF 25V; 0603
C34, C47, C48, C137: 0.1uF 10V; 0603
C37, C39: 47nF 16V; 0603
C38, C44, C152: 22uF 10V; 1206
C45, C46: 47uF 6.3V; 0603
C126, C279: 4.7uF 50V; 1206
C154: 1uF 6.3V; 0402
CN5: 15PIN 0.5MM; SFV15R-1STE1HLF
D1, D3: PESD5Z5.0; SC-79
D2: 20V TVS; DO214AC
D4, D5: B360A-13-F; DO214AC
D12, D13, D14: RED LED; 0603_POLAR
D15: BAT54S; SOT23-3
L1: 4.7uH; SRP1265A
L2: 6.8uH 3.6A; SRN6045
Q1, Q4, Q6: 2N7002; SOT23-3
Q2: FDN302P; SUPERSOT
Q5: SI7489DP; SO8_POWERPAK
R28, R65, R98, R99, R100, R101, R103, R104, R174, R175, R177: 10k; 0402
R29, R40: 0R01; 1206
R30, R32: 20k; 0603
R31: 33k; 0603
R33, R34, R37, R38: 33R; 0603
R39, R48, R49: 10k; 0603
R41: 0R25 1W; 2010
R42: 30k; 0402
R43: 158k; 0402
R45: 1k; 0603
R46: 2k; 0603
R56: 1.0k; 0603
R57: 100k; 0603
R58: 22k; 0603
R60, R76, R77: 120; 0402
R85: 28k; 0402
R86: 2k; 0402
R191: 20k; 0402
R192: 16k; 0402
TP54, TP72, TP87, TP88, TP89, TP90: 1MM_TEST_POINT; 1MM_TEST_PAD
U4: AP63300WU-7; SOT23-6
U5: STM32L431RBT; QFP64_SMALL
U7: ACT2861QI301-T; QFN32-ACT2861
U9: STUSB4500; QFN24
U16: INA180; SOT23-5
U19: SCHMITT; SOT23-5
U23: SN74LVC1G3; SOT23-5
U24: NAND; SC70-5
U40: ADJ BUCK; TI_MICROSIP_10

Connections:
ACT_I2C_SCL: U7.7 (SCL)
ACT_I2C_SDA: U7.6 (SDA)
ACT_ICOMP: C22.2, C24.2, U7.31 (ICOMP/GPIO)
ACT_NCHG: U5.27 (PB1), U7.28 (!CHG)
ACT_NINT: U5.28 (PB2), U7.10 (!IRQ)
BMS_I2C_SCL: CN5.5, U5.58 (PB6)
BMS_I2C_SDA: CN5.6, U5.59 (PB7)
BMS_NINT: CN5.7, U5.21 (PA5)
BMS_NPRESENT: CN5.10, R65.1, U5.20 (PA4)
BTN_THUMB: R99.2, TP72.1, U5.54 (PD2), U19.2 (A)
FPGA_DONE: U5.62 (PB9)
FPGA_NINIT: U5.61 (PB8)
FPGA_NPROG: U5.33 (PB12)
GND: C20.1, C21.1, C22.1, C23.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C33.1, C35.1, C38.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C55.1, C56.1, C57.1, C126.1, C134.1, C135.1, C136.1, C152.1, C154.1, C279.1, CN5.11, CN5.12, CN5.13, CN5.14, CN5.15, D1.A, D2.A, D3.A, D12.K, D13.K, D14.K, D15.1 (A), Q1.3 (S), Q4.3 (S), Q6.3 (S), R28.1, R30.1, R31.1, R32.1, R39.1, R42.1, R45.1, R49.1, R86.1, R98.1, R99.1, R103.1, R174.1, R191.1, U4.4 (GND), U5.12 (VSSA), U5.18 (VSS), U5.31 (VSS), U5.47 (VSS), U5.63 (VSS), U7.1 (AGND), U7.5 (PGND), U7.9 (SHIPM), U7.20 (PGND), U7.32 (EN_CHG), U7.EP (PGND), U9.10 (GND), U9.12 (ADDR0), U9.13 (ADDR1), U9.22 (VSYS), U9.TAB (GND), U16.2 (GND), U19.3 (GND)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; also elsewhere on the board
MON_SYS_BUS_A: C47.2, R45.2, R46.2, U5.8 (PC0)
MON_SYS_BUS_V: C154.2, D15.2 (AK), R85.2, R86.2, U5.9 (PC1)
unnamed: C34.2, L2.1, U4.5 (SW)
unnamed: C34.1, U4.6 (BST)
unnamed: C37.1, U7.25 (HSB1)
unnamed: R42.2, R43.1, U4.1 (FB)
unnamed: R46.1, U16.1 (OUT)
unnamed: C39.1, U7.15 (HSB2)
unnamed: C37.2, L1.1, U7.21 (SW1), U7.22 (SW1), U7.34 (SW1)
unnamed: C39.2, L1.2, U7.18 (SW2), U7.19 (SW2), U7.33 (SW2)
unnamed: C26.2, C28.2, R29.2, R34.1, U7.23 (VIN), U7.24 (VIN), U7.35 (VIN)
unnamed: C32.1, R34.2, U7.27 (ISRN)
unnamed: C32.2, R33.2, U7.26 (ISRP)
unnamed: R191.2, R192.1, U40.7 (FB)
unnamed: C30.2, U7.3 (INTBP)
unnamed: R32.2, U7.11 (OLIM)
unnamed: R31.2, U7.29 (ILIM)
unnamed: R39.2, U7.2 (TH)
unnamed: C24.1, R30.2
unnamed: C41.2, C42.2, R38.2, R40.1, U7.16 (VBAT), U7.17 (VBAT)
unnamed: C40.1, R38.1, U7.14 (OSRP)
unnamed: C40.2, R37.1, U7.13 (OSRN)
unnamed: C20.2, C137.1, R41.2, U4.2 (EN), U4.3 (VIN), U16.4 (IN-)
unnamed: U23.2 (B), U24.4 (Q)
unnamed: Q1.2 (D), Q2.1 (G), R48.2
unnamed: R28.2, U5.60 (PH3-BOOT0)
unnamed: U19.4 (Q), U23.1 (A)
unnamed: R56.1, U9.18 (VBUS_VS_DISCH)
unnamed: Q5.4 (G), R57.1, R58.2
unnamed: R58.1, U9.16 (VBUS_EN_SNK)
unnamed: C56.2, U9.23 (VREG_2V7)
unnamed: C55.2, U9.21 (VREG_1V2)
unnamed: D12.A, R60.1
unnamed: D13.A, R76.1
unnamed: D14.A, R77.1
PMC_LED_FPGA_OK: R76.2, U5.52 (PC11)
PMC_LED_RUN: R77.2, U5.51 (PC10)
PMC_LED_STATUS: R60.2, U5.53 (PC12)
PMC_NRESET: R104.1, U5.7 (NRST)
PMC_PSS_FLAG: U5.26 (PB0)
PMC_SWCLK: U5.49 (PA14)
PMC_SWDIO: U5.46 (PA13)
PMC_UART_RX: U5.43 (PA10)
PMC_UART_TX: U5.42 (PA9)
PSS_NRST: Q6.2 (D), R177.1
PSS_NRST_PMC: Q6.1 (G), R174.2, U5.24 (PC4)
PSS_NSRST: Q4.2 (D), R175.1
PSS_NSRST_PMC: Q4.1 (G), R98.2, U5.22 (PA6)
PSS_PMC_FLAG: U5.25 (PC5)
PSS_PMC_UART_RX: U5.17 (PA3)
PSS_PMC_UART_TX: U5.16 (PA2)
PWR_ACT_VREG: C33.2, U7.4 (VREG), U7.8 (!OTG)
PWR_ANA_1V8_EN: U5.57 (PB5)
PWR_DDR3_1V35_EN: U5.50 (PA15)
PWR_DIG_1V8_EN: U5.45 (PA12)
PWR_FPGA_1V0_EN: U5.55 (PB3)
PWR_SYS_1V8_SLP: C23.2, C25.2, C27.2, C29.2, C31.2, C35.2, C45.2, C46.2, C134.2, C135.2, C136.2, D15.3 (K), R65.2, R100.2, R101.2, R104.2, R192.2, TP54.1, U5.1 (VBAT), U5.13 (VDDA), U5.19 (VDD), U5.32 (VDD), U5.48 (VDD), U5.64 (VDD), U19.5 (VCC), U23.5 (V+), U24.5 (V+), U40.6 (VOUT)
PWR_SYS_3V3: R175.2, R177.2
PWR_SYS_3V3_EN: U5.44 (PA11)
PWR_SYS_5V: C38.2, C44.2, C48.2, C152.2, L2.2, R43.2, TP90.1, U16.5 (VCC); also elsewhere on the board
PWR_SYS_BUS: C137.2, Q2.3 (D), R41.1, R85.1, TP88.1, U16.3 (IN+)
PWR_SYS_STANDBY: C126.2, C279.2, D4.K, D5.K, Q2.2 (S), R48.1, TP89.1, U40.3 (VIN), U40.4 (EN)
PWR_USBC_VBUS: C57.2, D2.K (A1), Q5.1 (S), Q5.2 (S), Q5.3 (S), R56.2, R57.2, U9.24 (VDD)
PWR_USBC_VBUS_SW: C21.2, D5.A, Q5.5 (D), Q5.6 (D), Q5.7 (D), Q5.8 (D), Q5.PAD (D), R29.1, R33.1, TP87.1
PWR_VBAT: C43.2, CN5.1, CN5.2, CN5.3, CN5.4, D4.A, R37.2, R40.2, U7.12 (VBATS)
PWR_VBAT_EN: Q1.1 (G), R49.2, U5.15 (PA1)
STM_I2C2_SCL: U5.29 (PB10)
STM_I2C2_SDA: U5.30 (PB11)
STUSB_ATTACH: R100.1, U5.40 (PC9), U9.11 (ATTACH), U24.1 (A)
STUSB_GPIO: U5.38 (PC7), U9.15 (GPIO)
STUSB_I2C_SCL: U5.23 (PA7), U9.7 (SCL)
STUSB_I2C_SDA: U5.56 (PB4), U9.8 (SDA)
STUSB_NINT: R101.1, U5.36 (PB15), U9.19 (!ALERT), U24.2 (B)
STUSB_ORI: U5.37 (PC6), U9.17 (A_B_SIDE)
STUSB_PD0: U5.35 (PB14), U9.20 (POWER_OK2)
STUSB_PD1: U5.39 (PC8), U9.14 (POWER_OK3)
STUSB_RESET: R103.2, U5.41 (PA8), U9.6 (RESET)
SYS_WAKE: U5.14 (PA0), U23.4 (Q)
USBC_CC1: D3.K, U9.1 (CC1DB), U9.2 (CC1)
USBC_CC2: D1.K, U9.4 (CC2), U9.5 (CC2DB)

Notes on the sheet:
UNCONTROLLED WHEN PRINTED

Board: 8 copper layers, 142.0 x 95.0 mm, 224 parts (53 on the bottom side), 116 nets.

Other parts of the board:
MECH1, MECH2, MECH3, MECH4, MECH5, MECH6, MECH7, MECH8, MECH9, MECH10: 6mm x 3mm; MOUNTHOLE_6X3
