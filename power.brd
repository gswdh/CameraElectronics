File: power.brd (EAGLE design)
At the start: 136 x 136 mm, 31 parts, among them CN1 21700, CN2 21700, CN3 1 X 3 HEADER, CN4 21700, Q6 IRLML6244, Q7 IRLML6244, U17 MAX17320G20+

Commit message: New more simple desing
Parts:
- added C1, C2: 100nF 16V, CAPACITORS:0603
- added CN5: 15PIN 0.5MM, CONNECTORs:SFV15R-1STE1HLF
- added R1: 47R, r_0603:0603
- CN3: value 1 X 3 HEADER -> 21700; device CONNECTORs:3PIN_HEADER -> CONNECTORs:1122
- moved CN3 85.0 mm to (-13.5, -46.5), flipped to the bottom, turned to 180 degrees
- moved CN1 68.5 mm to (13.5, 46.5), turned to 0 degrees
- moved CN2 68.5 mm to (46.5, -13.5), turned to 90 degrees
- moved C122 23.8 mm to (13.1, 43.0)
- moved C123 23.8 mm to (13.1, 46.8)
- moved C124 23.8 mm to (24.6, 47.2)
- moved C125 23.8 mm to (10.8, 48.2)
- moved C126 23.8 mm to (5.25, 43.1)
- moved C127 23.8 mm to (9.88, 40.9)
- moved C128 23.8 mm to (7.75, 40.9)
- moved C129 23.8 mm to (3.25, 48.1)
- moved F1 23.8 mm to (21.2, 46.9)
- moved Q6 23.8 mm to (20.5, 54.4)
- moved Q7 23.8 mm to (20.5, 50.9)
- moved R38 23.8 mm to (9.12, 38.0)
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Connections:
- removed net N$40: C122.2, C123.1, R41.2, R42.2, U17.21, U17.22, U17.23
- new net N$1: C1.1, C122.2, R41.2, U17.21
- new net N$2: C123.1, C2.2, R42.2, U17.23
- new net N$3: C1.2, C2.1, R1.2, U17.22
- new net N$4: CN1.-, CN2.+, R42.1
- new net N$5: CN2.-, CN3.+, R1.1
- net N$36: now also CN1.+; no longer CN3.1
- net PACK_MID: now also CN3.-, CN4.+; no longer CN3.2, R42.1
- net PGND: now also CN4.-; no longer CN3.3
Routing:
- net N$5: track 0.00 -> 21.9 mm
- net N$4: track 0.00 -> 21.9 mm
- net PACK_MID: track 4.38 -> 21.9 mm
- net N$40: track 11.9 -> 0.00 mm
- net N$1: track 0.00 -> 4.19 mm
- net N$2: track 0.00 -> 3.83 mm
- net N$36: track 8.54 -> 7.13 mm
- net PGND: track 23.6 -> 22.6 mm
- added copper zone on layer 16, net PGND

Commit message: Lots of work
Parts:
- moved CN5 180.9 mm to (-92.8, -104.5)
- moved MECH1 55.0 mm to (-55.0, -65.0)
- moved MECH2 55.0 mm to (-65.0, 55.0)
- moved MECH3 55.0 mm to (55.0, 65.0)
- moved MECH4 55.0 mm to (65.0, -55.0)
Connections:
- removed net BMS_!ALRT: U17.7
- removed net VBAT: Q6.3, R49.2, R50.2
- new net BMS_BUS_RSVD_1: CN5.8
- new net BMS_BUS_RSVD_2: CN5.9
- new net BMS_NALERT: CN5.7, U17.7
- new net PWR_VPACK: CN5.1, CN5.2, CN5.3, CN5.4, Q6.3, R49.2, R50.2
- net BMS_I2C_SCL: now also CN5.5
- net BMS_I2C_SDA: now also CN5.6
- net GND: now also CN5.10, CN5.11, CN5.12, CN5.13, CN5.14, CN5.15
Routing:
- net VBAT: track 19.0 -> 0.00 mm, vias 2 -> 0
- net PWR_VPACK: track 0.00 -> 19.0 mm, vias 0 -> 2
- net BMS_NALERT: track 0.00 -> 5.92 mm
- net BMS_!ALRT: track 5.92 -> 0.00 mm
Changed lines of the file:
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@@
 <setting verticaltext="up"/>
 </settings>
-<grid distance="0.125" unitdist="mm" unit="mm" style="lines" multiple="1" display="yes" altdistance="0.125" altunitdist="mm" altunit="mm"/>
+<grid distance="0.125" unitdist="mm" unit="mm" style="lines" multiple="1" display="yes" altdistance="0.0625" altunitdist="mm" altunit="mm"/>
 <layers>
 <layer number="1" name="Top" color="4" fill="1" visible="yes" active="yes"/>
@@
 </layers>
 <board>
-<fusionsync huburn="a.YnVzaW5lc3M6bXl1Y2wxNDk2" projecturn="a.YnVzaW5lc3M6bXl1Y2wxNDk2IzIwMjExMjA3NDc0MjU0MzI2" f3durn="urn:adsk.wipprod:dm.lineage:-o3MW2fXTlyFglXsuSGDiA" pcbguid="" lastpulledtime="2022-04-18T10:55:57Z" lastsyncedchangeguid="" latestrevisionid="24a4b170-36f5-4312-b4fd-87fc221a1df7" lastsyncedrevisionid="24a4b170-36f5-4312-b4fd-87fc221a1df7" lastboardhashguid="3fffcd09-771c-5132-2f8a-175851c6f825" lastpushedtime="2022-04-19T08:21:16Z" linktopcb3d="true"/>
+<fusionsync huburn="a.YnVzaW5lc3M6bXl1Y2wxNDk2" projecturn="a.YnVzaW5lc3M6bXl1Y2wxNDk2IzIwMjExMjA3NDc0MjU0MzI2" f3durn="urn:adsk.wipprod:dm.lineage:-o3MW2fXTlyFglXsuSGDiA" pcbguid="" lastpulledtime="2022-04-18T10:55:57Z" lastsyncedchangeguid="" latestrevisionid="24a4b170-36f5-4312-b4fd-87fc221a1df7" lastsyncedrevisionid="24a4b170-36f5-4312-b4fd-87fc221a1df7" lastboardhashguid="3fffcd09-771c-5132-2f8a-175851c6f825" lastpushedtime="2022-04-19T08:21:16Z" linktopcb3d="false"/>
 <plain>
 <wire x1="-24" y1="31" x2="24" y2="31" width="0" layer="20" locked="yes"/>
@@
 <attribute name="PRICE_PER" value="0.36" x="21.25" y="46.875" size="1.778" layer="27" rot="R270" display="off"/>
 </element>
-<element name="MECH1" library="MISC" package="MOUNTHOLE_6X3" value="6mm x 3mm" x="0" y="-65" locked="yes" smashed="yes"/>
-<element name="MECH2" library="MISC" package="MOUNTHOLE_6X3" value="6mm x 3mm" x="-65" y="0" locked="yes" smashed="yes"/>
-<element name="MECH3" library="MISC" package="MOUNTHOLE_6X3" value="6mm x 3mm" x="0" y="65" locked="yes" smashed="yes"/>
-<element name="MECH4" library="MISC" package="MOUNTHOLE_6X3" value="6mm x 3mm" x="65" y="0" locked="yes" smashed="yes"/>
+<element name="MECH1" library="MISC" package="MOUNTHOLE_6X3" value="6mm x 3mm" x="-55" y="-65" locked="yes" smashed="yes"/>
+<element name="MECH2" library="MISC" package="MOUNTHOLE_6X3" value="6mm x 3mm" x="-65" y="55" locked="yes" smashed="yes"/>
+<element name="MECH3" library="MISC" package="MOUNTHOLE_6X3" value="6mm x 3mm" x="55" y="65" locked="yes" smashed="yes"/>
+<element name="MECH4" library="MISC" package="MOUNTHOLE_6X3" value="6mm x 3mm" x="65" y="-55" locked="yes" smashed="yes"/>
 <element name="CN1" library="CONNECTORs" package="1122" value="21700" x="13.5" y="46.5" smashed="yes" rot="MR0">
 <attribute name="DIGIKEY" value="36-1122-ND" x="13.5" y="46.5" size="1.778" layer="28" rot="MR0" display="off"/>
@@
 <attribute name="PRICE_PER" value="4.1" x="-13.5" y="-46.5" size="1.778" layer="28" rot="MR180" display="off"/>
 </element>
-<element name="CN5" library="CONNECTORs" package="SFV15R-1STE1HLF" value="15PIN 0.5MM" x="43" y="15" smashed="yes">
-<attribute name="DIGIKEY" value="609-4311-1-ND" x="43" y="15" size="1.778" layer="27" display="off"/>
-<attribute name="HEIGHT" value="1.8" x="43" y="15" size="1.778" layer="27" display="off"/>
-<attribute name="NAME" x="36.25" y="17.875" size="1" layer="25"/>
-<attribute name="PRICE_PER" value="0.46" x="43" y="15" size="1.778" layer="27" display="off"/>
+<element name="CN5" library="CONNECTORs" package="SFV15R-1STE1HLF" value="15PIN 0.5MM" x="-92.75" y="-104.5" smashed="yes">
+<attribute name="DIGIKEY" value="609-4311-1-ND" x="-92.75" y="-104.5" size="1.778" layer="27" display="off"/>
+<attribute name="HEIGHT" value="1.8" x="-92.75" y="-104.5" size="1.778" layer="27" display="off"/>
+<attribute name="NAME" x="-99.5" y="-101.625" size="1" layer="25"/>
+<attribute name="PRICE_PER" value="0.46" x="-92.75" y="-104.5" size="1.778" layer="27" display="off"/>
 </element>
 </elements>
@@
 <wire x1="2.75" y1="49.375" x2="2.25" y2="48.875" width="0.15" layer="1"/>
 <via x="2.25" y="48.875" extent="1-16" drill="0.3"/>
-<wire x1="4.5" y1="43.125" x2="3.25" y2="48.875" width="0" layer="19" extent="1-1"/>
-<wire x1="8.375" y1="42.795" x2="4.5" y2="43.125" width="0" layer="19" extent="1-1"/>
-</signal>
-<signal name="VBAT">
-<contactref element="Q6" pad="3"/>
-<contactref element="R49" pad="2"/>
-<contactref element="R50" pad="2"/>
-<wire x1="4.5" y1="48.875" x2="5.75" y2="48.875" width="0.15" layer="1"/>
-<wire x1="19.5" y1="55.375" x2="19.375" y2="55.375" width="0.5" layer="1"/>
-<wire x1="19.375" y1="55.375" x2="13.375" y2="55.375" width="1" layer="1"/>
-<via x="12.75" y="56.375" extent="1-16" drill="0.3"/>
-<wire x1="12.75" y1="56.375" x2="12.75" y2="53.75" width="0.15" layer="16"/>
-<wire x1="12.75" y1="53.75" x2="7.875" y2="48.875" width="0.15" layer="16"/>
-<wire x1="7.875" y1="48.875" x2="6.75" y2="48.875" width="0.15" layer="16"/>
-<via x="6.75" y="48.875" extent="1-16" drill="0.3"/>
-<wire x1="6.75" y1="48.875" x2="5.75" y2="48.875" width="0.15" layer="1"/>
-<wire x1="12.75" y1="56.375" x2="13.375" y2="55.375" width="0" layer="19" extent="1-1"/>
+<contactref element="CN5" pad="11"/>
+<contactref element="CN5" pad="12"/>
+<contactref element="CN5" pad="14"/>
+<contactref element="CN5" pad="13"/>
+<contactref element="CN5" pad="15"/>
+<contactref element="CN5" pad="10"/>
+<wire x1="-91.25" y1="-106.375" x2="-91.75" y2="-106.375" width="0" layer="19" extent="1-1"/>
+<wire x1="-90.75" y1="-106.375" x2="-91.25" y2="-106.375" width="0" layer="19" extent="1-1"/>
+<wire x1="-90.25" y1="-106.375" x2="-90.75" y2="-106.375" width="0" layer="19" extent="1-1"/>
+<wire x1="-89.75" y1="-106.375" x2="-90.25" y2="-106.375" width="0" layer="19" extent="1-1"/>
+<wire x1="-89.25" y1="-106.375" x2="-89.75" y2="-106.375" width="0" layer="19" extent="1-1"/>
+<wire x1="7.625" y1="38" x2="-89.25" y2="-106.375" width="0" layer="19" extent="1-1"/>
+<wire x1="4.5" y1="43.125" x2="8.375" y2="42.795" width="0" layer="19" extent="1-1"/>
+<wire x1="3.25" y1="48.875" x2="4.5" y2="43.125" width="0" layer="19" extent="1-1"/>
 </signal>
 <signal name="N$36">
@@
 <wire x1="9.625" y1="49.125" x2="16" y2="49.125" width="0.15" layer="1"/>
 </signal>
-<signal name="BMS_!ALRT">
-<contactref element="U17" pad="7"/>
-<wire x1="7.17" y1="46" x2="1.25" y2="46" width="0.15" layer="1"/>
-</signal>
 <signal name="BMS_I2C_SCL">
 <contactref element="U17" pad="8"/>
 <wire x1="7.17" y1="45.5" x2="1.25" y2="45.5" width="0.15" layer="1"/>
+<contactref element="CN5" pad="5"/>
+<wire x1="1.25" y1="45.5" x2="-94.25" y2="-106.375" width="0" layer="19" extent="1-1"/>
 </signal>
 <signal name="BMS_I2C_SDA">
 <contactref element="U17" pad="9"/>
 <wire x1="7.17" y1="45" x2="1.25" y2="45" width="0.15" layer="1"/>
+<contactref element="CN5" pad="6"/>
+<wire x1="1.25" y1="45" x2="-93.75" y2="-106.375" width="0" layer="19" extent="1-1"/>
 </signal>
 <signal name="N$1">
@@
 <wire x1="28.25" y1="-46.5" x2="-5.5" y2="43.25" width="0" layer="19" extent="1-16"/>
 </signal>
+<signal name="PWR_VPACK">
+<contactref element="CN5" pad="2"/>
+<contactref element="CN5" pad="1"/>
+<contactref element="CN5" pad="3"/>
+<contactref element="CN5" pad="4"/>
+<contactref element="Q6" pad="3"/>
+<contactref element="R49" pad="2"/>
+<contactref element="R50" pad="2"/>
+<wire x1="4.5" y1="48.875" x2="5.75" y2="48.875" width="0.15" layer="1"/>
+<wire x1="19.5" y1="55.375" x2="19.375" y2="55.375" width="0.5" layer="1"/>
+<wire x1="19.375" y1="55.375" x2="13.375" y2="55.375" width="1" layer="1"/>
+<via x="12.75" y="56.375" extent="1-16" drill="0.3"/>
+<wire x1="12.75" y1="56.375" x2="12.75" y2="53.75" width="0.15" layer="16"/>
+<wire x1="12.75" y1="53.75" x2="7.875" y2="48.875" width="0.15" layer="16"/>
+<wire x1="7.875" y1="48.875" x2="6.75" y2="48.875" width="0.15" layer="16"/>
+<via x="6.75" y="48.875" extent="1-16" drill="0.3"/>
+<wire x1="6.75" y1="48.875" x2="5.75" y2="48.875" width="0.15" layer="1"/>
+<wire x1="-96.25" y1="-106.375" x2="-95.75" y2="-106.375" width="0" layer="19" extent="1-1"/>
+<wire x1="-95.25" y1="-106.375" x2="-95.75" y2="-106.375" width="0" layer="19" extent="1-1"/>
+<wire x1="-94.75" y1="-106.375" x2="-95.25" y2="-106.375" width="0" layer="19" extent="1-1"/>
+<wire x1="4.5" y1="48.875" x2="-94.75" y2="-106.375" width="0" layer="19" extent="1-1"/>
+<wire x1="13.375" y1="55.375" x2="12.75" y2="56.375" width="0" layer="19" extent="1-1"/>
+</signal>
+<signal name="BMS_NALERT">
+<contactref element="CN5" pad="7"/>
+<contactref element="U17" pad="7"/>
+<wire x1="7.17" y1="46" x2="1.25" y2="46" width="0.15" layer="1"/>
+<wire x1="1.25" y1="46" x2="-93.25" y2="-106.375" width="0" layer="19" extent="1-1"/>
+</signal>
+<signal name="BMS_BUS_RSVD_1">
+<contactref element="CN5" pad="8"/>
+</signal>
+<signal name="BMS_BUS_RSVD_2">
+<contactref element="CN5" pad="9"/>
+</signal>
 </signals>

Commit message: Mech design and layout
Parts:
- added MECH5, MECH6: 6mm x 3mm, MISC:MOUNTHOLE_6X3
- moved CN5 175.9 mm to (0.00, 45.0)
- moved MECH2 38.8 mm to (-27.5, 65.0)
- moved MECH4 38.8 mm to (27.5, -65.0)
- moved R1 36.7 mm to (30.1, 54.6), turned to 270 degrees
- moved C1 34.8 mm to (26.9, 54.6), turned to 270 degrees
- moved C2 33.5 mm to (23.6, 54.6), turned to 270 degrees
- moved MECH1 27.5 mm to (-27.5, -65.0)
- moved MECH3 27.5 mm to (27.5, 65.0)
- moved C122 20.0 mm to (33.1, 42.4)
- moved C123 20.0 mm to (33.1, 46.1)
- moved C124 20.0 mm to (44.6, 46.6)
- moved C125 20.0 mm to (30.8, 47.6)
- moved C126 20.0 mm to (25.2, 42.5)
- moved C127 20.0 mm to (29.9, 40.2)
- moved C128 20.0 mm to (27.8, 40.2)
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Other:
- outline, holes or cut-outs redrawn
