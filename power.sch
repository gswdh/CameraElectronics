File: power.sch (EAGLE design)
At the start: 31 parts, among them CN1 21700, CN2 21700, CN3 1 X 3 HEADER, CN4 21700, Q6 IRLML6244, Q7 IRLML6244, U17 MAX17320G20+

Commit message: New more simple desing
Parts:
- added C1, C2: 100nF 16V, CAPACITORS:CL10B104KO8WPNC
- added CN5: 15PIN 0.5MM, CONNECTORs:SFV15R-1STE1HLF
- added R1: 47R, r_0603:ERJ3EKF47R0V
- CN3: value 1 X 3 HEADER -> 21700; device CONNECTORs:1X3_HEADER -> CONNECTORs:KEYSTONE1122
Connections:
- removed net N$40: C122.2, C123.1, R41.2, R42.2, U17.CELL1, U17.CELL2, U17.CELL3
- new net N$1: C1.1, C122.2, R41.2, U17.CELL1
- new net N$2: C123.1, C2.2, R42.2, U17.CELL3
- new net N$3: C1.2, C2.1, R1.2, U17.CELL2
- new net N$4: CN1.V-, CN2.V+, R42.1
- new net N$5: CN2.V-, CN3.V+, R1.1
- net N$36: now also CN1.V+; no longer CN3.1
- net PACK_MID: now also CN3.V-, CN4.V+; no longer CN3.2, R42.1
- net PGND: now also CN4.V-; no longer CN3.3
Other:
- moved on the sheet: CN1, CN2, CN4, F1

Commit message: Lots of work
Connections:
- removed net BMS_!ALRT: U17.ALRT
- removed net VBAT: Q6.S, R49.2, R50.2
- new net BMS_BUS_RSVD_1: CN5.8
- new net BMS_BUS_RSVD_2: CN5.9
- new net BMS_NALERT: CN5.7, U17.ALRT
- new net PWR_VPACK: CN5.1, CN5.2, CN5.3, CN5.4, Q6.S, R49.2, R50.2
- net BMS_I2C_SCL: now also CN5.5
- net BMS_I2C_SDA: now also CN5.6
- net GND: now also CN5.10, CN5.11, CN5.12, CN5.13, CN5.14, CN5.15
Other:
- note removed: "TODO: Replace with NTC"
- moved on the sheet: CN5
Changed lines of the file:
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@@
 <part name="CN3" library="CONNECTORs" deviceset="KEYSTONE1122" device="" value="21700"/>
 <part name="CN5" library="CONNECTORs" deviceset="SFV15R-1STE1HLF" device="" value="15PIN 0.5MM"/>
+<part name="GND4" library="NETS" deviceset="GND" device=""/>
 </parts>
 <sheets>
@@
 <wire x1="416.56" y1="309.88" x2="416.56" y2="279.4" width="0.1524" layer="114"/>
 <wire x1="401.32" y1="294.64" x2="431.8" y2="294.64" width="0.1524" layer="114"/>
-<text x="50.8" y="-43.18" size="1.778" layer="91">TODO: Replace with NTC</text>
 <wire x1="-406.4" y1="-292.1" x2="406.4" y2="-292.1" width="0.1524" layer="97"/>
 <wire x1="-406.4" y1="292.1" x2="-406.4" y2="-292.1" width="0.1524" layer="97"/>
@@
 <attribute name="VALUE" x="-46.99" y="-22.86" size="1.778" layer="96" rot="R90" align="center"/>
 </instance>
-<instance part="CN5" gate="G$1" x="114.3" y="7.62" smashed="yes">
-<attribute name="NAME" x="109.22" y="33.02" size="1.778" layer="95"/>
-<attribute name="VALUE" x="109.22" y="30.48" size="1.778" layer="96"/>
+<instance part="CN5" gate="G$1" x="91.44" y="22.86" smashed="yes">
+<attribute name="NAME" x="86.36" y="48.26" size="1.778" layer="95"/>
+<attribute name="VALUE" x="86.36" y="45.72" size="1.778" layer="96"/>
+</instance>
+<instance part="GND4" gate="G$1" x="101.6" y="0" smashed="yes">
+<attribute name="VALUE" x="101.6" y="-2.54" size="1.778" layer="96" align="center"/>
 </instance>
 </instances>
@@
 <wire x1="30.48" y1="20.32" x2="30.48" y2="17.78" width="0.1524" layer="91"/>
 </segment>
-</net>
-<net name="VBAT" class="0">
-<segment>
-<wire x1="10.16" y1="91.44" x2="35.56" y2="91.44" width="0.1524" layer="91"/>
-<wire x1="43.18" y1="91.44" x2="68.58" y2="91.44" width="0.1524" layer="91"/>
-<pinref part="Q6" gate="G$1" pin="S"/>
-<pinref part="R49" gate="G$1" pin="2"/>
-<wire x1="43.18" y1="48.26" x2="43.18" y2="91.44" width="0.1524" layer="91"/>
-<junction x="43.18" y="91.44"/>
-<pinref part="R50" gate="G$1" pin="2"/>
-<wire x1="35.56" y1="48.26" x2="35.56" y2="91.44" width="0.1524" layer="91"/>
-<junction x="35.56" y="91.44"/>
-<wire x1="43.18" y1="91.44" x2="35.56" y2="91.44" width="0.1524" layer="91"/>
+<segment>
+<pinref part="CN5" gate="G$1" pin="11"/>
+<wire x1="99.06" y1="15.24" x2="101.6" y2="15.24" width="0.1524" layer="91"/>
+<wire x1="101.6" y1="15.24" x2="101.6" y2="12.7" width="0.1524" layer="91"/>
+<pinref part="CN5" gate="G$1" pin="12"/>
+<wire x1="101.6" y1="12.7" x2="101.6" y2="10.16" width="0.1524" layer="91"/>
+<wire x1="101.6" y1="10.16" x2="101.6" y2="7.62" width="0.1524" layer="91"/>
+<wire x1="101.6" y1="7.62" x2="101.6" y2="5.08" width="0.1524" layer="91"/>
+<wire x1="101.6" y1="5.08" x2="101.6" y2="2.54" width="0.1524" layer="91"/>
+<wire x1="99.06" y1="12.7" x2="101.6" y2="12.7" width="0.1524" layer="91"/>
+<junction x="101.6" y="12.7"/>
+<pinref part="CN5" gate="G$1" pin="14"/>
+<wire x1="99.06" y1="7.62" x2="101.6" y2="7.62" width="0.1524" layer="91"/>
+<junction x="101.6" y="7.62"/>
+<pinref part="CN5" gate="G$1" pin="13"/>
+<wire x1="99.06" y1="10.16" x2="101.6" y2="10.16" width="0.1524" layer="91"/>
+<junction x="101.6" y="10.16"/>
+<pinref part="CN5" gate="G$1" pin="15"/>
+<wire x1="99.06" y1="5.08" x2="101.6" y2="5.08" width="0.1524" layer="91"/>
+<junction x="101.6" y="5.08"/>
+<pinref part="GND4" gate="G$1" pin="GND"/>
+<pinref part="CN5" gate="G$1" pin="10"/>
+<wire x1="99.06" y1="17.78" x2="101.6" y2="17.78" width="0.1524" layer="91"/>
+<wire x1="101.6" y1="17.78" x2="101.6" y2="15.24" width="0.1524" layer="91"/>
+<junction x="101.6" y="15.24"/>
 </segment>
 </net>
@@
 </segment>
 </net>
-<net name="BMS_!ALRT" class="0">
-<segment>
-<pinref part="U17" gate="G$1" pin="ALRT"/>
-<wire x1="15.24" y1="-20.32" x2="50.8" y2="-20.32" width="0.1524" layer="91"/>
-<label x="17.78" y="-20.32" size="1.778" layer="95"/>
-</segment>
-</net>
 <net name="BMS_I2C_SCL" class="0">
 <segment>
@@
 <label x="17.78" y="-15.24" size="1.778" layer="95"/>
 </segment>
+<segment>
+<pinref part="CN5" gate="G$1" pin="5"/>
+<wire x1="99.06" y1="30.48" x2="134.62" y2="30.48" width="0.1524" layer="91"/>
+<label x="104.14" y="30.48" size="1.778" layer="95"/>
+</segment>
 </net>
 <net name="BMS_I2C_SDA" class="0">
@@
 <wire x1="15.24" y1="-17.78" x2="50.8" y2="-17.78" width="0.1524" layer="91"/>
 <label x="17.78" y="-17.78" size="1.778" layer="95"/>
+</segment>
+<segment>
+<pinref part="CN5" gate="G$1" pin="6"/>
+<wire x1="99.06" y1="27.94" x2="134.62" y2="27.94" width="0.1524" layer="91"/>
+<label x="104.14" y="27.94" size="1.778" layer="95"/>
 </segment>
 </net>
@@
 </segment>
 </net>
+<net name="PWR_VPACK" class="0">
+<segment>
+<pinref part="CN5" gate="G$1" pin="2"/>
+<wire x1="99.06" y1="38.1" x2="101.6" y2="38.1" width="0.1524" layer="91"/>
+<pinref part="CN5" gate="G$1" pin="1"/>
+<wire x1="99.06" y1="40.64" x2="101.6" y2="40.64" width="0.1524" layer="91"/>
+<wire x1="101.6" y1="40.64" x2="134.62" y2="40.64" width="0.1524" layer="91"/>
+<wire x1="101.6" y1="38.1" x2="101.6" y2="40.64" width="0.1524" layer="91"/>
+<junction x="101.6" y="40.64"/>
+<pinref part="CN5" gate="G$1" pin="3"/>
+<wire x1="99.06" y1="35.56" x2="101.6" y2="35.56" width="0.1524" layer="91"/>
+<wire x1="101.6" y1="35.56" x2="101.6" y2="38.1" width="0.1524" layer="91"/>
+<junction x="101.6" y="38.1"/>
+<pinref part="CN5" gate="G$1" pin="4"/>
+<wire x1="99.06" y1="33.02" x2="101.6" y2="33.02" width="0.1524" layer="91"/>
+<wire x1="101.6" y1="33.02" x2="101.6" y2="35.56" width="0.1524" layer="91"/>
+<junction x="101.6" y="35.56"/>
+<label x="104.14" y="40.64" size="1.778" layer="95"/>
+</segment>
+<segment>
+<wire x1="10.16" y1="91.44" x2="35.56" y2="91.44" width="0.1524" layer="91"/>
+<wire x1="43.18" y1="91.44" x2="106.68" y2="91.44" width="0.1524" layer="91"/>
+<pinref part="Q6" gate="G$1" pin="S"/>
+<pinref part="R49" gate="G$1" pin="2"/>
+<wire x1="43.18" y1="48.26" x2="43.18" y2="91.44" width="0.1524" layer="91"/>
+<junction x="43.18" y="91.44"/>
+<pinref part="R50" gate="G$1" pin="2"/>
+<wire x1="35.56" y1="48.26" x2="35.56" y2="91.44" width="0.1524" layer="91"/>
+<junction x="35.56" y="91.44"/>
+<wire x1="43.18" y1="91.44" x2="35.56" y2="91.44" width="0.1524" layer="91"/>
+<label x="83.82" y="91.44" size="1.778" layer="95"/>
+</segment>
+</net>
+<net name="BMS_NALERT" class="0">
+<segment>
+<pinref part="CN5" gate="G$1" pin="7"/>
+<wire x1="99.06" y1="25.4" x2="134.62" y2="25.4" width="0.1524" layer="91"/>
+<label x="104.14" y="25.4" size="1.778" layer="95"/>
+</segment>
+<segment>
+<pinref part="U17" gate="G$1" pin="ALRT"/>
+<wire x1="15.24" y1="-20.32" x2="50.8" y2="-20.32" width="0.1524" layer="91"/>
+<label x="17.78" y="-20.32" size="1.778" layer="95"/>
+</segment>
+</net>
+<net name="BMS_BUS_RSVD_1" class="0">
+<segment>
+<pinref part="CN5" gate="G$1" pin="8"/>
+<wire x1="99.06" y1="22.86" x2="134.62" y2="22.86" width="0.1524" layer="91"/>
+<label x="104.14" y="22.86" size="1.778" layer="95"/>
+</segment>
+</net>
+<net name="BMS_BUS_RSVD_2" class="0">
+<segment>
+<pinref part="CN5" gate="G$1" pin="9"/>
+<wire x1="99.06" y1="20.32" x2="134.62" y2="20.32" width="0.1524" layer="91"/>
+<label x="104.14" y="20.32" size="1.778" layer="95"/>
+</segment>
+</net>

Commit message: Mech design and layout
Parts:
- added MECH5, MECH6: 6mm x 3mm, MISC:MOUNTHOLE
Changed lines of the file:
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@@
 <part name="CN5" library="CONNECTORs" deviceset="SFV15R-1STE1HLF" device="" value="15PIN 0.5MM"/>
 <part name="GND4" library="NETS" deviceset="GND" device=""/>
+<part name="MECH5" library="MISC" deviceset="MOUNTHOLE" device="" value="6mm x 3mm"/>
+<part name="MECH6" library="MISC" deviceset="MOUNTHOLE" device="" value="6mm x 3mm"/>
 </parts>
 <sheets>
@@
 <attribute name="VALUE" x="101.6" y="-2.54" size="1.778" layer="96" align="center"/>
 </instance>
+<instance part="MECH5" gate="G$1" x="-246.38" y="-109.22" smashed="yes">
+<attribute name="NAME" x="-246.38" y="-105.664" size="1.27" layer="95" align="center"/>
+</instance>
+<instance part="MECH6" gate="G$1" x="-198.12" y="-109.22" smashed="yes">
+<attribute name="NAME" x="-198.12" y="-105.664" size="1.27" layer="95" align="center"/>
+</instance>
 </instances>

Commit message: Battery PCB done
Parts:
- removed C123: 100nF 16V, CAPACITORS:CL10B104KO8WPNC
- removed R47: 10R, r_0603:ERJ3EKF10R0V
- added C3: 100nF 16V, CAPACITORS:CL10B104KO8WPNC
- added R4: 47R, r_0603:ERJ3EKF47R0V
- R1: value 47R -> 10R; device r_0603:ERJ3EKF47R0V -> r_0603:ERJ3EKF10R0V
- renumbered C122 to C4, C124 to C5, C125 to C6, C126 to C7, C127 to C8, C128 to C9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
Connections:
- net GND: no longer C10.1, C7.2
- net N$1: now also C3.1; no longer C1.1
- net N$2: now also C1.1; no longer C123.1
- net N$3: now also C3.2, R4.2; no longer C1.2, R1.2
- net N$36: now also R1.1; no longer R47.1
- net N$38: now also R1.2; no longer R47.2
- net N$39: now also C1.2; no longer C123.2
- net N$5: now also R4.1; no longer R1.1
- net PGND: now also C10.1, C7.2
Other:
- note added: "UNCONTROLLED WHEN PRINTED"
- note added: "YYYY.MM.DD - GSWDH LTD. CAMERA MAIN PCB REVISION 1.x.x DESIGN BY GEORGE WALLER, GSWDH LTD. GEORGEWALLER@GSWDH.CO.UK CONFIDENTIAL. FOR THE INTENDED READER ONLY."
- note removed: "2021.04.29 - GSWDH Ltd. Camera Electronics Revision x.x.x _ IN PROGRESS Designed by George Waller at GSWDH Ltd. georgewaller@gswdh.co.uk"

Commit message: debug board done
Parts:
- added R13: 10R, r_0603:ERJ3EKF10R0V
Connections:
- new net N$6: R13.2, U1.CSP
- net PGND: now also R13.1; no longer U1.CSP
Other:
- moved on the sheet: R8
Changed lines of the file:
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@@
 <part name="MECH6" library="MISC" deviceset="MOUNTHOLE" device="" value="6mm x 3mm"/>
 <part name="U$2" library="NETS" deviceset="PGND" device=""/>
+<part name="R13" library="r_0603" deviceset="ERJ3EKF10R0V" device="" value="10R"/>
 </parts>
 <sheets>
@@
 <attribute name="VALUE" x="-33.02" y="7.62" size="1.27" layer="96" rot="R90" align="center"/>
 </instance>
-<instance part="R8" gate="G$1" x="0" y="-73.66" smashed="yes" rot="R180">
-<attribute name="NAME" x="0" y="-76.2" size="1.27" layer="95" rot="R180" align="center"/>
-<attribute name="VALUE" x="0" y="-71.12" size="1.27" layer="96" rot="R180" align="center"/>
+<instance part="R8" gate="G$1" x="0" y="-86.36" smashed="yes" rot="R180">
+<attribute name="NAME" x="0" y="-88.9" size="1.27" layer="95" rot="R180" align="center"/>
+<attribute name="VALUE" x="0" y="-83.82" size="1.27" layer="96" rot="R180" align="center"/>
 </instance>
 <instance part="C5" gate="G$1" x="-30.48" y="30.48" smashed="yes" rot="R90">
@@
 <attribute name="VALUE" x="22.86" y="-2.54" size="1.27" layer="96" align="center"/>
 </instance>
-<instance part="U$20" gate="G$1" x="-7.62" y="-78.74" smashed="yes">
-<attribute name="VALUE" x="-7.62" y="-81.28" size="1.778" layer="96" align="center"/>
-</instance>
-<instance part="GND2" gate="G$1" x="7.62" y="-78.74" smashed="yes">
-<attribute name="VALUE" x="7.62" y="-81.28" size="1.778" layer="96" align="center"/>
+<instance part="U$20" gate="G$1" x="-7.62" y="-91.44" smashed="yes">
+<attribute name="VALUE" x="-7.62" y="-93.98" size="1.778" layer="96" align="center"/>
+</instance>
+<instance part="GND2" gate="G$1" x="7.62" y="-91.44" smashed="yes">
+<attribute name="VALUE" x="7.62" y="-93.98" size="1.778" layer="96" align="center"/>
 </instance>
 <instance part="U$21" gate="G$1" x="-30.48" y="20.32" smashed="yes">
@@
 <instance part="U$2" gate="G$1" x="43.18" y="17.78" smashed="yes">
 <attribute name="VALUE" x="43.18" y="15.24" size="1.778" layer="96" align="center"/>
+</instance>
+<instance part="R13" gate="G$1" x="-7.62" y="-78.74" smashed="yes" rot="R90">
+<attribute name="NAME" x="-10.16" y="-78.74" size="1.27" layer="95" rot="R90" align="center"/>
+<attribute name="VALUE" x="-5.08" y="-78.74" size="1.27" layer="96" rot="R90" align="center"/>
 </instance>
 </instances>
@@
 <segment>
 <pinref part="R8" gate="G$1" pin="1"/>
-<wire x1="5.08" y1="-73.66" x2="7.62" y2="-73.66" width="0.1524" layer="91"/>
+<wire x1="5.08" y1="-86.36" x2="7.62" y2="-86.36" width="0.1524" layer="91"/>
 <pinref part="U1" gate="G$1" pin="CSN"/>
-<wire x1="7.62" y1="-71.12" x2="7.62" y2="-73.66" width="0.1524" layer="91"/>
-<junction x="7.62" y="-73.66"/>
+<wire x1="7.62" y1="-71.12" x2="7.62" y2="-86.36" width="0.1524" layer="91"/>
+<junction x="7.62" y="-86.36"/>
 <pinref part="GND2" gate="G$1" pin="GND"/>
-<wire x1="7.62" y1="-76.2" x2="7.62" y2="-73.66" width="0.1524" layer="91"/>
+<wire x1="7.62" y1="-88.9" x2="7.62" y2="-86.36" width="0.1524" layer="91"/>
 </segment>
 <segment>
@@
 <segment>
 <pinref part="R8" gate="G$1" pin="2"/>
-<wire x1="-5.08" y1="-73.66" x2="-7.62" y2="-73.66" width="0.1524" layer="91"/>
-<pinref part="U1" gate="G$1" pin="CSP"/>
-<wire x1="-7.62" y1="-71.12" x2="-7.62" y2="-73.66" width="0.1524" layer="91"/>
-<junction x="-7.62" y="-73.66"/>
+<wire x1="-5.08" y1="-86.36" x2="-7.62" y2="-86.36" width="0.1524" layer="91"/>
+<junction x="-7.62" y="-86.36"/>
 <pinref part="U$20" gate="G$1" pin="PGND"/>
-<wire x1="-7.62" y1="-76.2" x2="-7.62" y2="-73.66" width="0.1524" layer="91"/>
+<wire x1="-7.62" y1="-88.9" x2="-7.62" y2="-86.36" width="0.1524" layer="91"/>
+<wire x1="-7.62" y1="-83.82" x2="-7.62" y2="-86.36" width="0.1524" layer="91"/>
+<pinref part="R13" gate="G$1" pin="1"/>
 </segment>
 <segment>
@@
 </segment>
 </net>
+<net name="N$6" class="0">
+<segment>
+<pinref part="U1" gate="G$1" pin="CSP"/>
+<wire x1="-7.62" y1="-71.12" x2="-7.62" y2="-73.66" width="0.1524" layer="91"/>
+<pinref part="R13" gate="G$1" pin="2"/>
+</segment>
+</net>
